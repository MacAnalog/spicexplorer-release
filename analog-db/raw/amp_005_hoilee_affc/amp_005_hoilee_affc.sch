v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_005_hoilee_affc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1640 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1315 390 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -110 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 60 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 1860 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 285 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -510 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1190 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -850 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -510 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 60 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 1415 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 1860 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 285 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 60 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 625 0 0 0 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 965 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_nmos_np.sym} 625 260 0 0 {name=M60 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm60_w l=x_dut_xm60_l m=x_dut_xm60_m}
C {devices/sg13_lv_nmos_np.sym} 625 520 0 0 {name=M61 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 1190 0 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 965 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 965 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 1415 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} -290 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 90 {}
N -1210 170 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 660 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -930 520 -930 614 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 490 {}
N -870 550 -870 660 {}
N -800 520 -800 580 {}
N -590 0 -590 94 {}
N -590 260 -590 354 {}
N -590 520 -590 614 {}
N -530 -140 -530 -30 {}
N -530 30 -530 70 {}
N -530 170 -530 230 {}
N -530 290 -530 490 {}
N -530 550 -530 660 {}
N -490 0 -490 70 {}
N -460 520 -460 580 {}
N -370 260 -370 354 {}
N -310 170 -310 230 {}
N -310 290 -310 320 {}
N -190 0 -190 94 {}
N -130 -140 -130 -30 {}
N -130 30 -130 70 {}
N -90 0 -90 70 {}
N 10 -60 10 0 {}
N 10 520 10 580 {}
N 20 30 20 230 {}
N 80 -140 80 -30 {}
N 80 30 80 90 {}
N 80 290 80 490 {}
N 80 550 80 660 {}
N 140 0 140 94 {}
N 140 260 140 354 {}
N 140 520 140 614 {}
N 235 -60 235 0 {}
N 265 190 265 260 {}
N 305 -140 305 -30 {}
N 305 30 305 90 {}
N 305 170 305 230 {}
N 305 290 305 660 {}
N 365 0 365 94 {}
N 365 260 365 354 {}
N 575 520 575 580 {}
N 605 0 605 70 {}
N 645 -140 645 -30 {}
N 645 30 645 70 {}
N 645 170 645 230 {}
N 645 290 645 350 {}
N 645 430 645 490 {}
N 645 550 645 660 {}
N 705 0 705 94 {}
N 705 260 705 354 {}
N 705 520 705 614 {}
N 915 520 915 580 {}
N 925 390 925 460 {}
N 985 -140 985 -30 {}
N 985 30 985 90 {}
N 985 170 985 230 {}
N 985 290 985 350 {}
N 985 460 985 490 {}
N 985 550 985 660 {}
N 1045 0 1045 94 {}
N 1045 260 1045 354 {}
N 1045 520 1045 614 {}
N 1210 -140 1210 -30 {}
N 1210 30 1210 90 {}
N 1210 170 1210 230 {}
N 1210 290 1210 350 {}
N 1270 0 1270 94 {}
N 1270 260 1270 354 {}
N 1435 -140 1435 -30 {}
N 1435 30 1435 230 {}
N 1435 290 1435 660 {}
N 1495 0 1495 94 {}
N 1495 260 1495 354 {}
N 1640 200 1640 230 {}
N 1640 290 1640 390 {}
N 1810 200 1810 260 {}
N 1840 -60 1840 0 {}
N 1880 -140 1880 -30 {}
N 1880 30 1880 230 {}
N 1880 290 1880 660 {}
N 1940 0 1940 94 {}
N 1940 200 1940 320 {}
N -2030 -140 2360 -140 {}
N 10 -60 235 -60 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -490 0 -430 0 {}
N -190 0 -130 0 {}
N -90 0 70 0 {}
N 80 0 140 0 {}
N 235 0 265 0 {}
N 305 0 365 0 {}
N 545 0 605 0 {}
N 645 0 705 0 {}
N 885 0 945 0 {}
N 985 0 1045 0 {}
N 1110 0 1170 0 {}
N 1210 0 1270 0 {}
N 1335 0 1395 0 {}
N 1435 0 1495 0 {}
N 1810 0 1840 0 {}
N 1880 0 1940 0 {}
N 20 30 80 30 {}
N -530 70 -490 70 {}
N -130 70 -90 70 {}
N 605 70 645 70 {}
N -1550 190 -1510 190 {}
N 265 190 305 190 {}
N 1435 200 1810 200 {}
N 1880 200 1940 200 {}
N 20 230 80 230 {}
N -1610 260 -1550 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -930 260 -870 260 {}
N -830 260 -770 260 {}
N -590 260 -530 260 {}
N -490 260 -430 260 {}
N -370 260 -310 260 {}
N -270 260 -240 260 {}
N -50 260 40 260 {}
N 80 260 140 260 {}
N 305 260 365 260 {}
N 545 260 605 260 {}
N 645 260 705 260 {}
N 885 260 945 260 {}
N 985 260 1045 260 {}
N 1110 260 1170 260 {}
N 1210 260 1270 260 {}
N 1335 260 1395 260 {}
N 1435 260 1495 260 {}
N 1810 260 1840 260 {}
N -530 320 -310 320 {}
N 1640 320 1940 320 {}
N 925 390 1285 390 {}
N 1345 390 1640 390 {}
N 925 460 985 460 {}
N -1270 520 -1210 520 {}
N -1170 520 -1110 520 {}
N -930 520 -870 520 {}
N -830 520 -770 520 {}
N -590 520 -530 520 {}
N -490 520 40 520 {}
N 80 520 140 520 {}
N 575 520 605 520 {}
N 645 520 705 520 {}
N 915 520 945 520 {}
N 985 520 1045 520 {}
N -800 580 -460 580 {}
N 10 580 915 580 {}
N -2030 660 2360 660 {}
C {devices/lab_wire.sym} -870 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -870 170 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} -530 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} -770 260 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} -430 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 305 170 0 1 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 305 90 2 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 545 260 0 0 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 885 260 0 0 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 1110 260 0 0 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -1210 170 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -1110 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} -770 520 0 1 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 1880 90 2 0 {name=l15 lab=VOUT}
C {devices/lab_wire.sym} -430 0 0 1 {name=l16 lab=VOUTN}
C {devices/lab_wire.sym} -530 170 0 1 {name=l17 lab=VOUTN}
C {devices/lab_wire.sym} 885 0 0 0 {name=l18 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l19 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l20 lab=net013}
C {devices/lab_wire.sym} -90 60 2 0 {name=l21 lab=net013}
C {devices/lab_wire.sym} 1335 0 0 0 {name=l22 lab=net013}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l23 lab=net043}
C {devices/lab_wire.sym} 1335 260 0 0 {name=l24 lab=net043}
C {devices/lab_wire.sym} 1435 90 2 0 {name=l25 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l26 lab=net050}
C {devices/lab_wire.sym} 985 90 2 0 {name=l27 lab=net050}
C {devices/lab_wire.sym} 985 170 0 1 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1210 90 2 0 {name=l29 lab=net050}
C {devices/lab_wire.sym} 1210 170 0 1 {name=l30 lab=net050}
C {devices/lab_wire.sym} 1840 -60 0 1 {name=l31 lab=net050}
C {devices/lab_wire.sym} 80 350 2 0 {name=l32 lab=net063}
C {devices/lab_wire.sym} 1210 350 2 0 {name=l33 lab=net063}
C {devices/lab_wire.sym} 985 350 2 0 {name=l34 lab=net1}
C {devices/lab_wire.sym} 1225 390 0 0 {name=l35 lab=net1}
C {devices/lab_wire.sym} 545 0 0 0 {name=l36 lab=net2}
C {devices/lab_wire.sym} 645 170 0 1 {name=l37 lab=net2}
C {devices/lab_wire.sym} 1110 0 0 0 {name=l38 lab=net2}
C {devices/lab_wire.sym} 645 350 2 0 {name=l39 lab=net3}
C {devices/lab_wire.sym} 645 430 0 1 {name=l40 lab=net3}
C {devices/lab_wire.sym} -310 170 0 1 {name=l41 lab=net31}
C {devices/lab_wire.sym} 80 90 2 0 {name=l42 lab=net31}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l43 lab=net54}
C {devices/lab_wire.sym} -870 350 2 0 {name=l44 lab=net56}
C {devices/lab_wire.sym} 140 354 2 0 {name=l45 lab=net31}
C {devices/lab_wire.sym} -370 354 2 0 {name=l46 lab=net31}
C {devices/lab_wire.sym} -190 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} 1940 94 2 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} 365 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} 140 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -590 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} 705 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} 1045 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 1270 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 1495 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} 365 354 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} -590 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} 1270 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} -930 614 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -590 614 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} 140 614 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} 1495 354 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 1880 260 0 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 705 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} 705 614 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 1045 354 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} 1045 614 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l75 lab=net013}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l76 lab=vss}
C {devices/ipin.sym} -240 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -50 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
