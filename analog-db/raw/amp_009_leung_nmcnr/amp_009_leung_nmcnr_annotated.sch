v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_009_leung_nmcnr} -1785 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1970 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 2185 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1745 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 1090 260 1 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -680 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -340 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -1020 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 520 260 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 180 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1300 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1740 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1020 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 520 520 0 0 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 1300 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 520 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1740 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 860 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -340 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 180 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1300 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1740 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 860 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1525 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2450 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1745 430 -1745 490 {}
N -1745 550 -1745 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 660 {}
N -1340 190 -1340 260 {}
N -1100 60 -1100 230 {}
N -1100 260 -1100 354 {}
N -1100 520 -1100 614 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 90 {}
N -1040 290 -1040 490 {}
N -1040 550 -1040 660 {}
N -910 230 -910 520 {}
N -760 0 -760 94 {}
N -700 -140 -700 -30 {}
N -700 30 -700 70 {}
N -660 -60 -660 70 {}
N -420 60 -420 230 {}
N -420 260 -420 354 {}
N -360 -140 -360 -30 {}
N -360 30 -360 90 {}
N -360 290 -360 660 {}
N -320 260 -320 320 {}
N -290 -60 -290 0 {}
N -220 -60 -220 0 {}
N -150 -140 -150 -30 {}
N -150 30 -150 90 {}
N -90 0 -90 94 {}
N 100 0 100 94 {}
N 100 260 100 354 {}
N 160 -140 160 -30 {}
N 160 30 160 90 {}
N 160 170 160 230 {}
N 160 290 160 660 {}
N 200 190 200 260 {}
N 230 -60 230 0 {}
N 470 -60 470 0 {}
N 470 520 470 580 {}
N 480 30 480 230 {}
N 540 -140 540 -30 {}
N 540 30 540 90 {}
N 540 290 540 490 {}
N 540 550 540 660 {}
N 600 0 600 94 {}
N 600 260 600 354 {}
N 600 520 600 614 {}
N 810 -60 810 0 {}
N 880 -140 880 -30 {}
N 880 30 880 90 {}
N 880 170 880 230 {}
N 880 290 880 660 {}
N 940 0 940 94 {}
N 940 260 940 354 {}
N 1120 260 1120 320 {}
N 1250 520 1250 580 {}
N 1280 0 1280 70 {}
N 1320 -140 1320 -30 {}
N 1320 30 1320 70 {}
N 1320 200 1320 230 {}
N 1320 290 1320 490 {}
N 1320 550 1320 660 {}
N 1380 30 1380 200 {}
N 1380 260 1380 354 {}
N 1380 520 1380 614 {}
N 1545 200 1545 230 {}
N 1545 290 1545 320 {}
N 1605 60 1605 200 {}
N 1605 260 1605 354 {}
N 1690 520 1690 580 {}
N 1760 -140 1760 -30 {}
N 1760 30 1760 90 {}
N 1760 170 1760 230 {}
N 1760 290 1760 320 {}
N 1760 320 1760 490 {}
N 1760 550 1760 660 {}
N 1820 0 1820 94 {}
N 1820 260 1820 354 {}
N 1820 520 1820 614 {}
N 2185 170 2185 230 {}
N 2185 290 2185 350 {}
N 2470 200 2470 230 {}
N 2470 290 2470 320 {}
N 2530 260 2530 354 {}
N -1860 -140 2925 -140 {}
N -660 -60 -290 -60 {}
N -220 -60 230 -60 {}
N 470 -60 810 -60 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1000 0 -940 0 {}
N -760 0 -700 0 {}
N -660 0 -600 0 {}
N -320 0 -190 0 {}
N -150 0 -90 0 {}
N 100 0 160 0 {}
N 200 0 500 0 {}
N 540 0 600 0 {}
N 810 0 840 0 {}
N 880 0 940 0 {}
N 1220 0 1280 0 {}
N 1660 0 1720 0 {}
N 1760 0 1820 0 {}
N 480 30 540 30 {}
N 1320 30 1380 30 {}
N -1100 60 -1040 60 {}
N -420 60 -360 60 {}
N -150 60 1605 60 {}
N -700 70 -660 70 {}
N 1280 70 1320 70 {}
N -1380 190 -1340 190 {}
N 160 190 200 190 {}
N 1320 200 1380 200 {}
N 1485 200 2470 200 {}
N -1100 230 -910 230 {}
N -420 230 -360 230 {}
N 480 230 540 230 {}
N -1440 260 -1380 260 {}
N -1100 260 -1040 260 {}
N -1000 260 -940 260 {}
N -420 260 -360 260 {}
N -320 260 -290 260 {}
N 100 260 160 260 {}
N 200 260 530 260 {}
N 540 260 600 260 {}
N 780 260 840 260 {}
N 880 260 940 260 {}
N 1000 260 1060 260 {}
N 1120 260 1150 260 {}
N 1220 260 1280 260 {}
N 1320 260 1380 260 {}
N 1415 260 1505 260 {}
N 1545 260 1605 260 {}
N 1660 260 1720 260 {}
N 1760 260 1820 260 {}
N 1880 260 1940 260 {}
N 2000 260 2030 260 {}
N 2340 260 2430 260 {}
N 2470 260 2530 260 {}
N 1320 320 1545 320 {}
N 1700 320 2470 320 {}
N -1100 520 -1040 520 {}
N -1000 520 500 520 {}
N 540 520 600 520 {}
N 1250 520 1280 520 {}
N 1320 520 1380 520 {}
N 1690 520 1720 520 {}
N 1760 520 1820 520 {}
N 470 580 1690 580 {}
N -1860 660 2925 660 {}
C {devices/lab_wire.sym} 540 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 1320 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -940 260 0 1 {name=l2 lab=VB3}
C {devices/lab_wire.sym} 160 90 2 0 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 160 170 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 1220 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 1660 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} -1040 90 2 0 {name=l7 lab=VB4}
C {devices/lab_wire.sym} -360 90 2 0 {name=l8 lab=VOUT}
C {devices/lab_wire.sym} 1000 260 0 0 {name=l9 lab=VOUT}
C {devices/lab_wire.sym} 1220 0 0 0 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 1660 0 0 0 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} -940 0 0 1 {name=l12 lab=net013}
C {devices/lab_wire.sym} -600 0 0 1 {name=l13 lab=net013}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l14 lab=net043}
C {devices/lab_wire.sym} 780 260 0 0 {name=l15 lab=net043}
C {devices/lab_wire.sym} 1120 320 2 0 {name=l16 lab=net044}
C {devices/lab_wire.sym} 1880 260 0 0 {name=l17 lab=net044}
C {devices/lab_wire.sym} 2185 170 0 1 {name=l18 lab=net044}
C {devices/lab_wire.sym} -320 320 2 0 {name=l19 lab=net049}
C {devices/lab_wire.sym} 880 90 2 0 {name=l20 lab=net049}
C {devices/lab_wire.sym} 880 170 0 1 {name=l21 lab=net049}
C {devices/lab_wire.sym} 2185 350 2 0 {name=l22 lab=net049}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l23 lab=net050}
C {devices/lab_wire.sym} 1760 90 2 0 {name=l24 lab=net050}
C {devices/lab_wire.sym} 1760 170 0 1 {name=l25 lab=net050}
C {devices/lab_wire.sym} 2000 260 0 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1760 350 2 0 {name=l27 lab=net063}
C {devices/lab_wire.sym} -150 90 2 0 {name=l28 lab=net31}
C {devices/lab_wire.sym} -1040 350 2 0 {name=l29 lab=net54}
C {devices/lab_wire.sym} 540 350 2 0 {name=l30 lab=net56}
C {devices/lab_wire.sym} 1605 354 2 0 {name=l31 lab=net31}
C {devices/lab_wire.sym} 2530 354 2 0 {name=l32 lab=net31}
C {devices/lab_wire.sym} -760 94 2 0 {name=l33 lab=vdd}
C {devices/lab_wire.sym} -1040 0 0 0 {name=l34 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} -360 0 0 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} 600 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} 100 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} -90 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 1320 0 0 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 1820 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} 940 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} -1100 354 2 0 {name=l43 lab=vss}
C {devices/lab_wire.sym} 600 354 2 0 {name=l44 lab=vss}
C {devices/lab_wire.sym} 100 354 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 1380 354 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} 1820 354 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} -1100 614 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 600 614 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} 1380 614 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} 1820 614 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} 940 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} -420 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} -1745 430 0 1 {name=l55 lab=net013}
C {devices/lab_wire.sym} -1745 610 2 0 {name=l56 lab=vss}
C {devices/ipin.sym} 1415 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2340 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1860 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1860 660 0 0 {name=p3 lab=vss}
B 8 -1476 -78 1316 78 {fill=0}
T {PMOS Simple Current Mirror (6 outputs)} -1476 -96 0 0 0.3 0.3 {layer=8}
B 10 -1500 182 1000 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1500 164 0 0 0.3 0.3 {layer=10}
B 12 -1840 182 1340 338 {fill=0}
T {NMOS Simple Current Mirror} -1840 164 0 0 0.3 0.3 {layer=12}
B 21 1230 -78 2196 78 {fill=0}
T {PMOS Simple Current Mirror} 1230 -96 0 0 0.3 0.3 {layer=21}
B 15 1455 182 2906 338 {fill=0}
T {PMOS Differential Pair} 1455 164 0 0 0.3 0.3 {layer=15}
