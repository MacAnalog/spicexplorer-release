v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_008_leung_nmcf} -1785 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1505 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1965 260 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1745 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -620 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -280 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 1720 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -280 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 60 260 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 495 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1020 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1280 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -280 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 60 520 0 0 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1020 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 60 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1280 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 835 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 1720 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 495 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 275 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1280 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 835 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} -800 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1060 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1745 430 -1745 490 {}
N -1745 550 -1745 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 660 {}
N -1340 190 -1340 260 {}
N -1100 0 -1100 94 {}
N -1100 260 -1100 354 {}
N -1100 520 -1100 614 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 70 {}
N -1040 170 -1040 230 {}
N -1040 290 -1040 490 {}
N -1040 550 -1040 660 {}
N -1000 0 -1000 70 {}
N -880 260 -880 354 {}
N -820 170 -820 230 {}
N -820 290 -820 320 {}
N -700 0 -700 94 {}
N -640 -140 -640 -30 {}
N -640 30 -640 70 {}
N -600 -60 -600 70 {}
N -360 30 -360 230 {}
N -360 260 -360 354 {}
N -360 520 -360 614 {}
N -300 -140 -300 -30 {}
N -300 30 -300 90 {}
N -300 290 -300 490 {}
N -300 550 -300 660 {}
N -230 -60 -230 0 {}
N -170 230 -170 520 {}
N 10 -60 10 0 {}
N 10 200 10 260 {}
N 10 520 10 580 {}
N 20 30 20 230 {}
N 80 -140 80 -30 {}
N 80 30 80 90 {}
N 80 290 80 490 {}
N 80 550 80 660 {}
N 140 0 140 94 {}
N 140 260 140 354 {}
N 140 520 140 614 {}
N 225 -60 225 0 {}
N 295 -140 295 -30 {}
N 295 30 295 90 {}
N 355 0 355 94 {}
N 475 190 475 260 {}
N 515 -140 515 -30 {}
N 515 30 515 90 {}
N 515 170 515 230 {}
N 515 290 515 660 {}
N 575 0 575 94 {}
N 575 260 575 354 {}
N 855 -140 855 -30 {}
N 855 30 855 90 {}
N 855 170 855 230 {}
N 855 290 855 660 {}
N 915 0 915 94 {}
N 915 260 915 354 {}
N 1080 170 1080 230 {}
N 1080 290 1080 350 {}
N 1140 260 1140 354 {}
N 1230 520 1230 580 {}
N 1260 -60 1260 0 {}
N 1300 -140 1300 -30 {}
N 1300 30 1300 90 {}
N 1300 170 1300 230 {}
N 1300 290 1300 490 {}
N 1300 550 1300 660 {}
N 1360 0 1360 94 {}
N 1360 260 1360 354 {}
N 1360 520 1360 614 {}
N 1505 170 1505 230 {}
N 1505 290 1505 320 {}
N 1740 -140 1740 -30 {}
N 1740 30 1740 230 {}
N 1740 290 1740 660 {}
N 1800 0 1800 94 {}
N 1800 200 1800 320 {}
N 1905 200 1905 260 {}
N 1995 260 1995 320 {}
N -1860 -140 2250 -140 {}
N -600 -60 -230 -60 {}
N 10 -60 225 -60 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1100 0 -1040 0 {}
N -1000 0 -940 0 {}
N -700 0 -640 0 {}
N -600 0 -540 0 {}
N -260 0 40 0 {}
N 80 0 140 0 {}
N 225 0 255 0 {}
N 295 0 355 0 {}
N 415 0 475 0 {}
N 515 0 575 0 {}
N 755 0 815 0 {}
N 855 0 915 0 {}
N 1230 0 1260 0 {}
N 1300 0 1360 0 {}
N 1640 0 1700 0 {}
N 1740 0 1800 0 {}
N -360 30 -300 30 {}
N 20 30 80 30 {}
N -1040 70 -1000 70 {}
N -640 70 -600 70 {}
N -1380 190 -1340 190 {}
N 475 190 515 190 {}
N 10 200 475 200 {}
N 1740 200 1905 200 {}
N -360 230 -170 230 {}
N 20 230 80 230 {}
N -1440 260 -1380 260 {}
N -1100 260 -1040 260 {}
N -1000 260 -940 260 {}
N -880 260 -820 260 {}
N -780 260 -750 260 {}
N -360 260 -300 260 {}
N -260 260 40 260 {}
N 80 260 140 260 {}
N 515 260 575 260 {}
N 755 260 815 260 {}
N 855 260 915 260 {}
N 950 260 1040 260 {}
N 1080 260 1140 260 {}
N 1200 260 1260 260 {}
N 1300 260 1360 260 {}
N 1640 260 1700 260 {}
N 1905 260 1935 260 {}
N 1995 260 2025 260 {}
N -1040 320 -820 320 {}
N 1080 320 1300 320 {}
N 1505 320 1800 320 {}
N -1100 520 -1040 520 {}
N -1000 520 -940 520 {}
N -360 520 -300 520 {}
N -260 520 40 520 {}
N 80 520 140 520 {}
N 1230 520 1260 520 {}
N 1300 520 1360 520 {}
N 10 580 1230 580 {}
N -1860 660 2250 660 {}
C {devices/lab_wire.sym} 80 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -1040 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -940 260 0 1 {name=l2 lab=VB3}
C {devices/lab_wire.sym} 515 170 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 515 90 2 0 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 1200 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -940 520 0 1 {name=l6 lab=VB4}
C {devices/lab_wire.sym} -300 90 2 0 {name=l7 lab=VB4}
C {devices/lab_wire.sym} 1740 90 2 0 {name=l8 lab=VOUT}
C {devices/lab_wire.sym} -940 0 0 1 {name=l9 lab=VOUTN}
C {devices/lab_wire.sym} -1040 170 0 1 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 1260 -60 0 1 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} -540 0 0 1 {name=l12 lab=net013}
C {devices/lab_wire.sym} 415 0 0 0 {name=l13 lab=net013}
C {devices/lab_wire.sym} 755 0 0 0 {name=l14 lab=net013}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l15 lab=net043}
C {devices/lab_wire.sym} 755 260 0 0 {name=l16 lab=net043}
C {devices/lab_wire.sym} 855 90 2 0 {name=l17 lab=net049}
C {devices/lab_wire.sym} 855 170 0 1 {name=l18 lab=net049}
C {devices/lab_wire.sym} 1640 260 0 0 {name=l19 lab=net049}
C {devices/lab_wire.sym} 1995 320 2 0 {name=l20 lab=net049}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l21 lab=net050}
C {devices/lab_wire.sym} 1300 90 2 0 {name=l22 lab=net050}
C {devices/lab_wire.sym} 1300 170 0 1 {name=l23 lab=net050}
C {devices/lab_wire.sym} 1505 170 0 1 {name=l24 lab=net050}
C {devices/lab_wire.sym} 1640 0 0 0 {name=l25 lab=net050}
C {devices/lab_wire.sym} 1080 350 2 0 {name=l26 lab=net063}
C {devices/lab_wire.sym} -820 170 0 1 {name=l27 lab=net31}
C {devices/lab_wire.sym} 295 90 2 0 {name=l28 lab=net31}
C {devices/lab_wire.sym} 1080 170 0 1 {name=l29 lab=net31}
C {devices/lab_wire.sym} -300 350 2 0 {name=l30 lab=net54}
C {devices/lab_wire.sym} 80 350 2 0 {name=l31 lab=net56}
C {devices/lab_wire.sym} -880 354 2 0 {name=l32 lab=net31}
C {devices/lab_wire.sym} 1140 354 2 0 {name=l33 lab=net31}
C {devices/lab_wire.sym} -700 94 2 0 {name=l34 lab=vdd}
C {devices/lab_wire.sym} -300 0 0 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} 1800 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} 140 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} 575 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 355 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} -1100 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} 1360 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 915 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -360 354 2 0 {name=l44 lab=vss}
C {devices/lab_wire.sym} 140 354 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 575 354 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} -1100 354 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} 1360 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} -360 614 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} 140 614 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} -1100 614 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} 1360 614 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} 915 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} 1740 260 0 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} -1745 430 0 1 {name=l56 lab=net013}
C {devices/lab_wire.sym} -1745 610 2 0 {name=l57 lab=vss}
C {devices/ipin.sym} -750 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 950 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1860 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1860 660 0 0 {name=p3 lab=vss}
