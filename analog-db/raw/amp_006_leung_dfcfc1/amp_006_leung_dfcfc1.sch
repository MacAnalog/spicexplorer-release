v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_006_leung_dfcfc1} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 480 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1050 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} 480 0 0 0 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -635 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -860 260 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 1605 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 1945 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -635 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 45 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -295 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1085 260 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -635 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 45 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 45 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1085 520 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 1605 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 820 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 1265 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 1945 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} -295 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 265 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} -1085 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 820 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1265 0 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} -1310 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1610 520 -1610 614 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 490 {}
N -1550 550 -1550 660 {}
N -1510 0 -1510 70 {}
N -1390 260 -1390 354 {}
N -1330 170 -1330 230 {}
N -1330 290 -1330 320 {}
N -1165 0 -1165 94 {}
N -1165 260 -1165 354 {}
N -1165 520 -1165 614 {}
N -1105 -140 -1105 -30 {}
N -1105 30 -1105 90 {}
N -1105 170 -1105 230 {}
N -1105 290 -1105 490 {}
N -1105 550 -1105 660 {}
N -1065 0 -1065 60 {}
N -940 260 -940 354 {}
N -880 170 -880 230 {}
N -880 290 -880 320 {}
N -715 0 -715 94 {}
N -715 260 -715 354 {}
N -715 520 -715 614 {}
N -655 -140 -655 -30 {}
N -655 30 -655 90 {}
N -655 170 -655 230 {}
N -655 290 -655 490 {}
N -655 550 -655 660 {}
N -585 -60 -585 0 {}
N -375 60 -375 230 {}
N -375 260 -375 354 {}
N -315 -140 -315 -30 {}
N -315 30 -315 90 {}
N -315 190 -315 230 {}
N -315 290 -315 660 {}
N -275 190 -275 260 {}
N -245 -60 -245 0 {}
N -5 -60 -5 0 {}
N 5 60 5 230 {}
N 65 -140 65 -30 {}
N 65 30 65 90 {}
N 65 290 65 490 {}
N 65 550 65 660 {}
N 125 0 125 94 {}
N 125 260 125 354 {}
N 125 520 125 614 {}
N 215 -60 215 0 {}
N 285 -140 285 -30 {}
N 285 30 285 90 {}
N 345 0 345 94 {}
N 460 0 460 70 {}
N 500 -140 500 -30 {}
N 500 30 500 70 {}
N 510 260 510 320 {}
N 560 0 560 94 {}
N 800 200 800 260 {}
N 840 -140 840 -30 {}
N 840 30 840 230 {}
N 840 290 840 660 {}
N 900 0 900 94 {}
N 900 260 900 354 {}
N 1050 200 1050 230 {}
N 1050 290 1050 320 {}
N 1215 200 1215 260 {}
N 1245 -60 1245 0 {}
N 1285 -140 1285 -30 {}
N 1285 30 1285 230 {}
N 1285 290 1285 660 {}
N 1345 0 1345 94 {}
N 1345 200 1345 320 {}
N 1585 190 1585 260 {}
N 1625 -140 1625 -30 {}
N 1625 30 1625 230 {}
N 1625 290 1625 660 {}
N 1685 0 1685 94 {}
N 1685 260 1685 354 {}
N 1965 -140 1965 -30 {}
N 1965 30 1965 230 {}
N 1965 290 1965 660 {}
N 2025 0 2025 94 {}
N 2025 260 2025 354 {}
N -2030 -140 2445 -140 {}
N -585 -60 -245 -60 {}
N -5 -60 215 -60 {}
N -1610 0 -1550 0 {}
N -1165 0 -1105 0 {}
N -1065 0 -1035 0 {}
N -715 0 -655 0 {}
N -615 0 -555 0 {}
N -275 0 25 0 {}
N 65 0 125 0 {}
N 215 0 245 0 {}
N 285 0 345 0 {}
N 400 0 460 0 {}
N 500 0 560 0 {}
N 740 0 800 0 {}
N 840 0 900 0 {}
N 1215 0 1245 0 {}
N 1285 0 1345 0 {}
N 1525 0 1585 0 {}
N 1625 0 1685 0 {}
N 1865 0 1925 0 {}
N 1965 0 2025 0 {}
N -375 60 -315 60 {}
N 5 60 65 60 {}
N -1550 70 -1510 70 {}
N 460 70 500 70 {}
N -315 190 -275 190 {}
N 1585 190 1625 190 {}
N 840 200 1215 200 {}
N 1285 200 1345 200 {}
N -375 230 -315 230 {}
N 5 230 65 230 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -1390 260 -1330 260 {}
N -1290 260 -1260 260 {}
N -1165 260 -1105 260 {}
N -1065 260 -1005 260 {}
N -940 260 -880 260 {}
N -840 260 -810 260 {}
N -715 260 -655 260 {}
N -615 260 -555 260 {}
N -375 260 -315 260 {}
N -275 260 55 260 {}
N 65 260 125 260 {}
N 390 260 450 260 {}
N 510 260 540 260 {}
N 770 260 800 260 {}
N 840 260 900 260 {}
N 1215 260 1245 260 {}
N 1625 260 1685 260 {}
N 1865 260 1925 260 {}
N 1965 260 2025 260 {}
N -1550 320 -1330 320 {}
N -1105 320 -880 320 {}
N 1050 320 1345 320 {}
N -1610 520 -1550 520 {}
N -1510 520 -1450 520 {}
N -1165 520 -1105 520 {}
N -1065 520 -1005 520 {}
N -715 520 -655 520 {}
N -615 520 25 520 {}
N 65 520 125 520 {}
N -2030 660 2445 660 {}
C {devices/lab_wire.sym} 65 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -1550 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l2 lab=VB3}
C {devices/lab_wire.sym} -1005 260 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} -555 260 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} -315 90 2 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -1450 520 0 1 {name=l6 lab=VB4}
C {devices/lab_wire.sym} -1005 520 0 1 {name=l7 lab=VB4}
C {devices/lab_wire.sym} -655 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} -655 170 0 1 {name=l9 lab=VB4}
C {devices/lab_wire.sym} -555 520 0 1 {name=l10 lab=VB4}
C {devices/lab_wire.sym} 390 260 0 0 {name=l11 lab=VOUT}
C {devices/lab_wire.sym} 1965 90 2 0 {name=l12 lab=VOUT}
C {devices/lab_wire.sym} -1510 60 2 0 {name=l13 lab=VOUTN}
C {devices/lab_wire.sym} -1065 60 2 0 {name=l14 lab=VOUTN}
C {devices/lab_wire.sym} -555 0 0 1 {name=l15 lab=net013}
C {devices/lab_wire.sym} 400 0 0 0 {name=l16 lab=net013}
C {devices/lab_wire.sym} 740 0 0 0 {name=l17 lab=net013}
C {devices/lab_wire.sym} 1245 -60 0 1 {name=l18 lab=net013}
C {devices/lab_wire.sym} 800 200 0 1 {name=l19 lab=net043}
C {devices/lab_wire.sym} 1625 90 2 0 {name=l20 lab=net043}
C {devices/lab_wire.sym} 840 90 2 0 {name=l21 lab=net049}
C {devices/lab_wire.sym} 1865 260 0 0 {name=l22 lab=net049}
C {devices/lab_wire.sym} -1105 90 2 0 {name=l23 lab=net050}
C {devices/lab_wire.sym} -1105 170 0 1 {name=l24 lab=net050}
C {devices/lab_wire.sym} 510 320 2 0 {name=l25 lab=net050}
C {devices/lab_wire.sym} 1525 0 0 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1865 0 0 0 {name=l27 lab=net050}
C {devices/lab_wire.sym} -1105 350 2 0 {name=l28 lab=net063}
C {devices/lab_wire.sym} 1285 90 2 0 {name=l29 lab=net1}
C {devices/lab_wire.sym} -1330 170 0 1 {name=l30 lab=net31}
C {devices/lab_wire.sym} -880 170 0 1 {name=l31 lab=net31}
C {devices/lab_wire.sym} 285 90 2 0 {name=l32 lab=net31}
C {devices/lab_wire.sym} -655 350 2 0 {name=l33 lab=net54}
C {devices/lab_wire.sym} 65 350 2 0 {name=l34 lab=net56}
C {devices/lab_wire.sym} -940 354 2 0 {name=l35 lab=net31}
C {devices/lab_wire.sym} -1390 354 2 0 {name=l36 lab=net31}
C {devices/lab_wire.sym} 560 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} -715 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} 1685 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 2025 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 125 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} -315 0 0 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 345 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} -1165 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 900 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 1345 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} -715 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 125 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} -375 354 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} -1165 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -715 614 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} 125 614 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} -1165 614 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} 1685 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} 900 354 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 1285 260 0 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} 2025 354 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l61 lab=net013}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l62 lab=vss}
C {devices/ipin.sym} -1260 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -810 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
