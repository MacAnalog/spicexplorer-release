v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_007_leung_dfcfc2} -1910 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1060 260 1 0 {name=C1 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1800 260 1 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1870 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -830 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 190 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 530 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -830 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -490 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -150 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1240 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1605 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -830 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -490 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -490 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1240 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1605 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 190 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 870 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 530 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} -150 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -1010 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1240 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1605 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 870 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1425 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2085 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1870 430 -1870 490 {}
N -1870 550 -1870 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -1090 0 -1090 94 {}
N -1030 -140 -1030 -30 {}
N -1030 30 -1030 90 {}
N -990 0 -990 60 {}
N -910 0 -910 94 {}
N -910 260 -910 354 {}
N -910 520 -910 614 {}
N -850 -140 -850 -30 {}
N -850 30 -850 90 {}
N -850 170 -850 230 {}
N -850 290 -850 490 {}
N -850 550 -850 660 {}
N -570 0 -570 94 {}
N -570 260 -570 354 {}
N -570 520 -570 614 {}
N -510 -140 -510 -30 {}
N -510 30 -510 90 {}
N -510 170 -510 230 {}
N -510 290 -510 490 {}
N -510 550 -510 660 {}
N -230 0 -230 94 {}
N -230 260 -230 354 {}
N -170 -140 -170 -30 {}
N -170 30 -170 90 {}
N -170 170 -170 230 {}
N -170 290 -170 660 {}
N -130 190 -130 260 {}
N 140 260 140 520 {}
N 210 -140 210 -30 {}
N 210 30 210 90 {}
N 210 170 210 230 {}
N 210 290 210 660 {}
N 270 0 270 94 {}
N 270 260 270 354 {}
N 550 -140 550 -30 {}
N 550 30 550 90 {}
N 550 170 550 230 {}
N 550 290 550 660 {}
N 610 0 610 94 {}
N 610 260 610 354 {}
N 890 -140 890 -30 {}
N 890 30 890 90 {}
N 890 170 890 230 {}
N 890 290 890 660 {}
N 950 0 950 94 {}
N 950 260 950 354 {}
N 1000 0 1000 260 {}
N 1090 260 1090 320 {}
N 1220 0 1220 70 {}
N 1220 200 1220 260 {}
N 1260 -140 1260 -30 {}
N 1260 30 1260 70 {}
N 1260 170 1260 230 {}
N 1260 290 1260 490 {}
N 1260 550 1260 660 {}
N 1320 0 1320 94 {}
N 1320 260 1320 354 {}
N 1320 520 1320 614 {}
N 1405 200 1405 260 {}
N 1445 170 1445 230 {}
N 1445 290 1445 320 {}
N 1505 260 1505 354 {}
N 1555 0 1555 60 {}
N 1585 200 1585 260 {}
N 1625 -140 1625 -30 {}
N 1625 30 1625 90 {}
N 1625 170 1625 230 {}
N 1625 290 1625 490 {}
N 1625 550 1625 660 {}
N 1685 0 1685 94 {}
N 1685 260 1685 354 {}
N 1685 520 1685 614 {}
N 1770 200 1770 260 {}
N 2065 200 2065 260 {}
N 2105 170 2105 230 {}
N 2105 290 2105 320 {}
N 2165 260 2165 354 {}
N -1930 -140 2295 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1090 0 -1030 0 {}
N -990 0 -960 0 {}
N -910 0 -850 0 {}
N -810 0 -750 0 {}
N -570 0 -510 0 {}
N -470 0 -410 0 {}
N -230 0 -170 0 {}
N -130 0 -70 0 {}
N 110 0 170 0 {}
N 210 0 270 0 {}
N 450 0 510 0 {}
N 550 0 610 0 {}
N 790 0 850 0 {}
N 890 0 950 0 {}
N 1160 0 1220 0 {}
N 1260 0 1320 0 {}
N 1525 0 1585 0 {}
N 1625 0 1685 0 {}
N -1210 70 -1170 70 {}
N 1220 70 1260 70 {}
N -1550 190 -1510 190 {}
N -170 190 -130 190 {}
N -1610 260 -1550 260 {}
N -910 260 -850 260 {}
N -810 260 -750 260 {}
N -570 260 -510 260 {}
N -470 260 -410 260 {}
N -230 260 -170 260 {}
N 110 260 170 260 {}
N 210 260 270 260 {}
N 450 260 510 260 {}
N 550 260 610 260 {}
N 790 260 850 260 {}
N 890 260 950 260 {}
N 970 260 1030 260 {}
N 1090 260 1120 260 {}
N 1190 260 1220 260 {}
N 1260 260 1320 260 {}
N 1375 260 1405 260 {}
N 1445 260 1505 260 {}
N 1555 260 1585 260 {}
N 1625 260 1685 260 {}
N 1740 260 1770 260 {}
N 1830 260 1860 260 {}
N 2035 260 2065 260 {}
N 2105 260 2165 260 {}
N 1260 320 1445 320 {}
N 1625 320 2105 320 {}
N -910 520 -850 520 {}
N -810 520 -750 520 {}
N -570 520 -510 520 {}
N -470 520 1220 520 {}
N 1260 520 1320 520 {}
N 1525 520 1585 520 {}
N 1625 520 1685 520 {}
N -1930 660 2295 660 {}
C {devices/lab_wire.sym} -1930 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -1930 660 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} -510 90 2 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} -510 170 0 1 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 1260 350 2 0 {name=l4 lab=DM_2}
C {devices/lab_wire.sym} -750 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -410 260 0 1 {name=l6 lab=VB3}
C {devices/lab_wire.sym} -170 90 2 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -170 170 0 1 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 1220 200 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 1585 200 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -850 90 2 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -850 170 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -750 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 110 260 0 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 1525 520 0 0 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1405 200 0 1 {name=l16 lab=VINN}
C {devices/lab_wire.sym} 2065 200 0 1 {name=l17 lab=VINP}
C {devices/lab_wire.sym} 550 90 2 0 {name=l18 lab=VOUT}
C {devices/lab_wire.sym} 550 170 0 1 {name=l19 lab=VOUT}
C {devices/lab_wire.sym} 1090 320 2 0 {name=l20 lab=VOUT}
C {devices/lab_wire.sym} 1160 0 0 0 {name=l21 lab=VOUTN}
C {devices/lab_wire.sym} 1260 170 0 1 {name=l22 lab=VOUTN}
C {devices/lab_wire.sym} 1525 0 0 0 {name=l23 lab=VOUTN}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l24 lab=net043}
C {devices/lab_wire.sym} 790 260 0 0 {name=l25 lab=net043}
C {devices/lab_wire.sym} 450 260 0 0 {name=l26 lab=net049}
C {devices/lab_wire.sym} 890 90 2 0 {name=l27 lab=net049}
C {devices/lab_wire.sym} 890 170 0 1 {name=l28 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l29 lab=net050}
C {devices/lab_wire.sym} 110 0 0 0 {name=l30 lab=net050}
C {devices/lab_wire.sym} 450 0 0 0 {name=l31 lab=net050}
C {devices/lab_wire.sym} 970 260 0 0 {name=l32 lab=net050}
C {devices/lab_wire.sym} 1625 90 2 0 {name=l33 lab=net050}
C {devices/lab_wire.sym} 1625 170 0 1 {name=l34 lab=net050}
C {devices/lab_wire.sym} 1770 200 0 1 {name=l35 lab=net050}
C {devices/lab_wire.sym} 1625 350 2 0 {name=l36 lab=net063}
C {devices/lab_wire.sym} -1170 60 2 0 {name=l37 lab=net1}
C {devices/lab_wire.sym} -990 60 2 0 {name=l38 lab=net1}
C {devices/lab_wire.sym} -750 0 0 1 {name=l39 lab=net1}
C {devices/lab_wire.sym} -410 0 0 1 {name=l40 lab=net1}
C {devices/lab_wire.sym} -70 0 0 1 {name=l41 lab=net1}
C {devices/lab_wire.sym} 790 0 0 0 {name=l42 lab=net1}
C {devices/lab_wire.sym} 210 90 2 0 {name=l43 lab=net2}
C {devices/lab_wire.sym} 210 170 0 1 {name=l44 lab=net2}
C {devices/lab_wire.sym} 1830 260 0 0 {name=l45 lab=net2}
C {devices/lab_wire.sym} -1030 90 2 0 {name=l46 lab=net31}
C {devices/lab_wire.sym} 1445 170 0 1 {name=l47 lab=net31}
C {devices/lab_wire.sym} 2105 170 0 1 {name=l48 lab=net31}
C {devices/lab_wire.sym} -850 350 2 0 {name=l49 lab=net54}
C {devices/lab_wire.sym} -510 350 2 0 {name=l50 lab=net56}
C {devices/lab_wire.sym} 1505 354 2 0 {name=l51 lab=net31}
C {devices/lab_wire.sym} 2165 354 2 0 {name=l52 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -910 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} 270 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 610 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} -570 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} -230 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} -1090 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} 1320 94 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} 1685 94 2 0 {name=l62 lab=vdd}
C {devices/lab_wire.sym} 950 94 2 0 {name=l63 lab=vdd}
C {devices/lab_wire.sym} -910 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} -570 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -230 354 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} 1320 354 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} 1685 354 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} -910 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} -570 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 1320 614 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} 1685 614 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 270 354 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} 950 354 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} 610 354 2 0 {name=l76 lab=vss}
C {devices/lab_wire.sym} -1870 430 0 1 {name=l77 lab=net1}
C {devices/lab_wire.sym} -1870 610 2 0 {name=l78 lab=vss}
C {devices/ipin.sym} -2070 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -2070 380 0 0 {name=p1 lab=VINP}
B 8 -1378 -78 1058 78 {fill=0}
T {PMOS Simple Current Mirror (5 outputs)} -1378 -96 0 0 0.3 0.3 {layer=8}
B 10 -1026 182 -80 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1026 164 0 0 0.3 0.3 {layer=10}
B 12 -1726 182 1066 338 {fill=0}
T {NMOS Simple Current Mirror} -1726 164 0 0 0.3 0.3 {layer=12}
B 21 1170 -78 1793 78 {fill=0}
T {PMOS Simple Current Mirror} 1170 -96 0 0 0.3 0.3 {layer=21}
B 15 1355 182 2273 338 {fill=0}
T {PMOS Differential Pair} 1355 164 0 0 0.3 0.3 {layer=15}
