v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_010_peng_acbc} -1785 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1815 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 925 260 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1745 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -680 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 2330 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 2030 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -680 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -140 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 255 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1145 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1590 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -680 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -140 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -140 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1145 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1590 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 700 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} -510 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 2030 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 255 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 75 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1145 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 475 0 0 0 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 1590 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 700 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} -460 0 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1370 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1745 430 -1745 490 {}
N -1745 550 -1745 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 660 {}
N -1340 190 -1340 260 {}
N -1100 0 -1100 94 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 70 {}
N -1000 0 -1000 70 {}
N -760 0 -760 94 {}
N -760 260 -760 354 {}
N -760 520 -760 614 {}
N -700 -140 -700 -30 {}
N -700 30 -700 90 {}
N -700 170 -700 230 {}
N -700 290 -700 490 {}
N -700 550 -700 660 {}
N -660 260 -660 320 {}
N -630 170 -630 580 {}
N -540 0 -540 94 {}
N -490 200 -490 230 {}
N -490 290 -490 660 {}
N -480 -140 -480 -30 {}
N -480 30 -480 200 {}
N -430 260 -430 354 {}
N -220 0 -220 94 {}
N -220 260 -220 354 {}
N -220 520 -220 614 {}
N -160 -140 -160 -30 {}
N -160 30 -160 90 {}
N -160 170 -160 230 {}
N -160 290 -160 490 {}
N -160 550 -160 660 {}
N -90 -60 -90 0 {}
N -90 520 -90 580 {}
N -5 0 -5 94 {}
N 55 -140 55 -30 {}
N 55 30 55 90 {}
N 125 -60 125 0 {}
N 215 30 215 200 {}
N 235 190 235 260 {}
N 275 -140 275 -30 {}
N 275 30 275 90 {}
N 275 190 275 230 {}
N 275 290 275 660 {}
N 335 0 335 94 {}
N 335 260 335 354 {}
N 455 0 455 70 {}
N 495 -140 495 -30 {}
N 495 30 495 70 {}
N 555 0 555 94 {}
N 720 -140 720 -30 {}
N 720 30 720 90 {}
N 720 170 720 230 {}
N 720 290 720 660 {}
N 780 0 780 94 {}
N 780 260 780 354 {}
N 985 200 985 260 {}
N 1095 520 1095 580 {}
N 1125 -60 1125 70 {}
N 1165 -140 1165 -30 {}
N 1165 30 1165 70 {}
N 1165 200 1165 230 {}
N 1165 290 1165 490 {}
N 1165 550 1165 660 {}
N 1225 30 1225 200 {}
N 1225 260 1225 354 {}
N 1225 520 1225 614 {}
N 1390 170 1390 200 {}
N 1390 200 1390 230 {}
N 1390 290 1390 320 {}
N 1450 260 1450 354 {}
N 1540 520 1540 580 {}
N 1570 -60 1570 0 {}
N 1610 -140 1610 -30 {}
N 1610 30 1610 90 {}
N 1610 170 1610 230 {}
N 1610 290 1610 320 {}
N 1610 320 1610 490 {}
N 1610 550 1610 660 {}
N 1670 0 1670 94 {}
N 1670 260 1670 354 {}
N 1670 520 1670 614 {}
N 1815 170 1815 230 {}
N 1815 290 1815 350 {}
N 2050 -140 2050 -30 {}
N 2050 30 2050 90 {}
N 2050 290 2050 660 {}
N 2110 60 2110 230 {}
N 2110 260 2110 354 {}
N 2350 200 2350 230 {}
N 2350 290 2350 320 {}
N 2410 260 2410 354 {}
N -1860 -140 2830 -140 {}
N -90 -60 125 -60 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1100 0 -1040 0 {}
N -1000 0 -940 0 {}
N -760 0 -700 0 {}
N -660 0 -600 0 {}
N -540 0 -480 0 {}
N -440 0 -380 0 {}
N -220 0 -160 0 {}
N -120 0 -60 0 {}
N -5 0 55 0 {}
N 95 0 235 0 {}
N 275 0 335 0 {}
N 395 0 455 0 {}
N 495 0 555 0 {}
N 620 0 680 0 {}
N 720 0 780 0 {}
N 1540 0 1570 0 {}
N 1610 0 1670 0 {}
N 1950 0 2010 0 {}
N 215 30 275 30 {}
N 1165 30 1225 30 {}
N 2050 60 2110 60 {}
N -1040 70 -1000 70 {}
N 455 70 495 70 {}
N 1125 70 1165 70 {}
N -700 170 -630 170 {}
N -1380 190 -1340 190 {}
N 235 190 275 190 {}
N -490 200 -480 200 {}
N 215 200 275 200 {}
N 720 200 985 200 {}
N 1165 200 1225 200 {}
N 1330 200 2350 200 {}
N 2050 230 2110 230 {}
N -1440 260 -1380 260 {}
N -760 260 -700 260 {}
N -590 260 -530 260 {}
N -490 260 -430 260 {}
N -220 260 -160 260 {}
N -120 260 -60 260 {}
N 275 260 335 260 {}
N 620 260 680 260 {}
N 720 260 780 260 {}
N 835 260 895 260 {}
N 955 260 985 260 {}
N 1065 260 1125 260 {}
N 1165 260 1225 260 {}
N 1260 260 1350 260 {}
N 1390 260 1450 260 {}
N 1510 260 1570 260 {}
N 1610 260 1670 260 {}
N 1950 260 2010 260 {}
N 2050 260 2110 260 {}
N 2220 260 2310 260 {}
N 2350 260 2410 260 {}
N 1165 320 1390 320 {}
N 1550 320 2350 320 {}
N -760 520 -700 520 {}
N -660 520 -630 520 {}
N -220 520 -160 520 {}
N -120 520 1125 520 {}
N 1165 520 1225 520 {}
N 1540 520 1570 520 {}
N 1610 520 1670 520 {}
N -630 580 -90 580 {}
N 1095 580 1540 580 {}
N -1860 660 2830 660 {}
C {devices/lab_wire.sym} -160 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -160 170 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 1165 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -660 320 2 0 {name=l3 lab=VB3}
C {devices/lab_wire.sym} -60 260 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 275 90 2 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 1065 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 1510 260 0 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -700 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} -700 170 0 1 {name=l9 lab=VB4}
C {devices/lab_wire.sym} 1815 350 2 0 {name=l10 lab=VOUT}
C {devices/lab_wire.sym} 2050 90 2 0 {name=l11 lab=VOUT}
C {devices/lab_wire.sym} 1125 -60 0 1 {name=l12 lab=VOUTN}
C {devices/lab_wire.sym} 1570 -60 0 1 {name=l13 lab=VOUTN}
C {devices/lab_wire.sym} -940 0 0 1 {name=l14 lab=net013}
C {devices/lab_wire.sym} -600 0 0 1 {name=l15 lab=net013}
C {devices/lab_wire.sym} -380 0 0 1 {name=l16 lab=net013}
C {devices/lab_wire.sym} -60 0 0 1 {name=l17 lab=net013}
C {devices/lab_wire.sym} 620 0 0 0 {name=l18 lab=net013}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l19 lab=net043}
C {devices/lab_wire.sym} -590 260 0 0 {name=l20 lab=net043}
C {devices/lab_wire.sym} 620 260 0 0 {name=l21 lab=net043}
C {devices/lab_wire.sym} 720 90 2 0 {name=l22 lab=net049}
C {devices/lab_wire.sym} 720 170 0 1 {name=l23 lab=net049}
C {devices/lab_wire.sym} 1950 260 0 0 {name=l24 lab=net049}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l25 lab=net050}
C {devices/lab_wire.sym} 1610 90 2 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1610 170 0 1 {name=l27 lab=net050}
C {devices/lab_wire.sym} 1815 170 0 1 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1950 0 0 0 {name=l29 lab=net050}
C {devices/lab_wire.sym} 1610 350 2 0 {name=l30 lab=net063}
C {devices/lab_wire.sym} -480 90 2 0 {name=l31 lab=net1}
C {devices/lab_wire.sym} 395 0 0 0 {name=l32 lab=net1}
C {devices/lab_wire.sym} 835 260 0 0 {name=l33 lab=net1}
C {devices/lab_wire.sym} 55 90 2 0 {name=l34 lab=net31}
C {devices/lab_wire.sym} 1390 170 0 1 {name=l35 lab=net31}
C {devices/lab_wire.sym} -700 350 2 0 {name=l36 lab=net54}
C {devices/lab_wire.sym} -160 350 2 0 {name=l37 lab=net56}
C {devices/lab_wire.sym} 2410 354 2 0 {name=l38 lab=net31}
C {devices/lab_wire.sym} 1450 354 2 0 {name=l39 lab=net31}
C {devices/lab_wire.sym} -1100 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} -760 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 2050 0 0 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -220 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 335 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} -5 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 1165 0 0 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 555 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} 1670 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} 780 94 2 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} -540 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} -760 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -220 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} 335 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} 1225 354 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} 1670 354 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} -760 614 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} -220 614 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 1225 614 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} 1670 614 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} 780 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -430 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} 2110 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} -1745 430 0 1 {name=l65 lab=net013}
C {devices/lab_wire.sym} -1745 610 2 0 {name=l66 lab=vss}
C {devices/ipin.sym} 1260 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2220 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1860 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1860 660 0 0 {name=p3 lab=vss}
B 8 -1476 -78 1156 78 {fill=0}
T {PMOS Simple Current Mirror (6 outputs)} -1476 -96 0 0 0.3 0.3 {layer=8}
B 10 -1160 182 735 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1160 164 0 0 0.3 0.3 {layer=10}
B 12 -1840 182 1180 338 {fill=0}
T {NMOS Simple Current Mirror (2 outputs)} -1840 164 0 0 0.3 0.3 {layer=12}
B 21 1075 -78 2046 78 {fill=0}
T {PMOS Simple Current Mirror} 1075 -96 0 0 0.3 0.3 {layer=21}
B 15 1300 182 2810 338 {fill=0}
T {PMOS Differential Pair} 1300 164 0 0 0.3 0.3 {layer=15}
