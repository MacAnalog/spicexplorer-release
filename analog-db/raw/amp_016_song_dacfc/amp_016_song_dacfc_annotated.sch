v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_016_song_dacfc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -310 390 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1685 780 0 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -310 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 360 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -310 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 585 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -745 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1935 520 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1685 520 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -310 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 585 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 360 780 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 585 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1910 780 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 360 520 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 1295 520 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} -745 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -530 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1345 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 360 260 0 1 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} 135 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} -965 0 0 1 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 1685 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 1345 260 0 0 {name=M60 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm60_w l=x_dut_xm60_l m=x_dut_xm60_m}
C {devices/sg13_lv_pmos_np.sym} 1685 260 0 0 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 2130 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_pmos_np.sym} 925 260 0 0 {name=M63 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 60 780 0 1 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_nmos_np.sym} 925 780 0 0 {name=M65 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 925 0 0 0 {name=M68 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_pmos_np.sym} 2130 0 0 0 {name=M69 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 135 0 0 1 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 925 520 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_nmos_np.sym} 60 520 0 1 {name=M71 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm71_w l=x_dut_xm71_l m=x_dut_xm71_m}
C {devices/sg13_lv_pmos_np.sym} -90 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1910 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 690 -1915 750 {}
N -1915 810 -1915 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 920 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -1045 0 -1045 94 {}
N -985 -140 -985 -30 {}
N -985 30 -985 90 {}
N -825 0 -825 94 {}
N -825 260 -825 354 {}
N -765 -140 -765 -30 {}
N -765 30 -765 90 {}
N -765 170 -765 230 {}
N -765 290 -765 920 {}
N -725 190 -725 260 {}
N -610 0 -610 94 {}
N -550 -140 -550 -30 {}
N -550 30 -550 90 {}
N -390 0 -390 94 {}
N -390 260 -390 354 {}
N -390 520 -390 614 {}
N -330 -140 -330 -30 {}
N -330 30 -330 90 {}
N -330 170 -330 230 {}
N -330 290 -330 490 {}
N -330 550 -330 920 {}
N -290 0 -290 60 {}
N -280 390 -280 450 {}
N -170 260 -170 354 {}
N -110 140 -110 230 {}
N -110 290 -110 350 {}
N -20 520 -20 614 {}
N -20 780 -20 874 {}
N 40 430 40 490 {}
N 40 550 40 750 {}
N 40 810 40 920 {}
N 55 0 55 94 {}
N 55 260 55 354 {}
N 110 780 110 840 {}
N 115 -140 115 -30 {}
N 115 30 115 90 {}
N 115 170 115 230 {}
N 115 290 115 350 {}
N 280 0 280 94 {}
N 280 260 280 354 {}
N 280 520 280 614 {}
N 280 780 280 874 {}
N 340 -140 340 -30 {}
N 340 30 340 90 {}
N 340 170 340 230 {}
N 340 290 340 350 {}
N 340 430 340 490 {}
N 340 550 340 610 {}
N 340 720 340 750 {}
N 340 810 340 920 {}
N 380 450 380 520 {}
N 410 780 410 840 {}
N 505 60 505 230 {}
N 505 290 505 490 {}
N 505 520 505 614 {}
N 565 -140 565 -30 {}
N 565 30 565 70 {}
N 565 170 565 230 {}
N 565 290 565 350 {}
N 565 550 565 920 {}
N 605 0 605 70 {}
N 695 520 695 780 {}
N 815 0 815 290 {}
N 885 60 885 230 {}
N 885 580 885 750 {}
N 905 170 905 260 {}
N 945 -140 945 -30 {}
N 945 30 945 90 {}
N 945 430 945 490 {}
N 945 550 945 610 {}
N 945 810 945 920 {}
N 1005 0 1005 94 {}
N 1005 260 1005 354 {}
N 1005 520 1005 614 {}
N 1005 780 1005 874 {}
N 1215 520 1215 614 {}
N 1275 430 1275 490 {}
N 1275 550 1275 920 {}
N 1295 200 1295 260 {}
N 1365 -140 1365 -30 {}
N 1365 30 1365 90 {}
N 1365 170 1365 230 {}
N 1365 290 1365 350 {}
N 1425 0 1425 94 {}
N 1425 260 1425 354 {}
N 1635 460 1635 520 {}
N 1685 690 1685 750 {}
N 1685 810 1685 920 {}
N 1705 -140 1705 -30 {}
N 1705 30 1705 90 {}
N 1705 170 1705 230 {}
N 1705 290 1705 350 {}
N 1705 430 1705 490 {}
N 1705 550 1705 610 {}
N 1765 0 1765 94 {}
N 1765 260 1765 354 {}
N 1765 520 1765 614 {}
N 1885 460 1885 520 {}
N 1895 320 1895 460 {}
N 1930 140 1930 230 {}
N 1930 290 1930 350 {}
N 1930 690 1930 750 {}
N 1930 810 1930 920 {}
N 1955 460 1955 490 {}
N 1955 550 1955 610 {}
N 1990 260 1990 354 {}
N 1990 780 1990 874 {}
N 2015 580 2015 720 {}
N 2110 -60 2110 0 {}
N 2150 -140 2150 -30 {}
N 2150 30 2150 230 {}
N 2150 290 2150 350 {}
N 2210 0 2210 94 {}
N 2210 260 2210 354 {}
N -2030 -140 2630 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -1045 0 -985 0 {}
N -945 0 -885 0 {}
N -825 0 -765 0 {}
N -725 0 -665 0 {}
N -610 0 -550 0 {}
N -510 0 -450 0 {}
N -390 0 -330 0 {}
N -290 0 -260 0 {}
N 55 0 115 0 {}
N 155 0 215 0 {}
N 280 0 340 0 {}
N 380 0 440 0 {}
N 605 0 665 0 {}
N 815 0 905 0 {}
N 945 0 1005 0 {}
N 1265 0 1325 0 {}
N 1365 0 1425 0 {}
N 1605 0 1665 0 {}
N 1705 0 1765 0 {}
N 2080 0 2110 0 {}
N 2150 0 2210 0 {}
N 505 60 565 60 {}
N 885 60 945 60 {}
N -1210 70 -1170 70 {}
N 565 70 605 70 {}
N -110 140 1930 140 {}
N 565 170 905 170 {}
N -765 190 -725 190 {}
N 905 200 1295 200 {}
N 505 230 565 230 {}
N 885 230 945 230 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -825 260 -765 260 {}
N -390 260 -330 260 {}
N -290 260 -230 260 {}
N -170 260 -110 260 {}
N -70 260 -10 260 {}
N 55 260 115 260 {}
N 155 260 215 260 {}
N 280 260 340 260 {}
N 380 260 440 260 {}
N 605 260 665 260 {}
N 945 260 1005 260 {}
N 1295 260 1325 260 {}
N 1365 260 1425 260 {}
N 1605 260 1665 260 {}
N 1705 260 1765 260 {}
N 1830 260 1890 260 {}
N 1930 260 1990 260 {}
N 2050 260 2110 260 {}
N 2150 260 2210 260 {}
N 505 290 565 290 {}
N 815 290 945 290 {}
N 1895 320 2150 320 {}
N -400 390 -340 390 {}
N -280 390 -250 390 {}
N 340 450 380 450 {}
N 1635 460 1885 460 {}
N 1895 460 1955 460 {}
N 505 490 565 490 {}
N -390 520 -330 520 {}
N -290 520 -230 520 {}
N -20 520 40 520 {}
N 80 520 140 520 {}
N 280 520 340 520 {}
N 505 520 565 520 {}
N 605 520 695 520 {}
N 845 520 905 520 {}
N 945 520 1005 520 {}
N 1215 520 1275 520 {}
N 1315 520 1375 520 {}
N 1605 520 1665 520 {}
N 1705 520 1765 520 {}
N 1885 520 1915 520 {}
N 885 580 945 580 {}
N 1955 580 2015 580 {}
N 340 720 2015 720 {}
N 885 750 945 750 {}
N -20 780 40 780 {}
N 80 780 110 780 {}
N 280 780 340 780 {}
N 380 780 905 780 {}
N 945 780 1005 780 {}
N 1830 780 1890 780 {}
N 1930 780 1990 780 {}
N 110 840 410 840 {}
N -2030 920 2630 920 {}
C {devices/lab_wire.sym} 665 0 0 1 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 1605 260 0 0 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 2050 260 0 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} -110 350 2 0 {name=l3 lab=DM_2}
C {devices/lab_wire.sym} 1955 610 2 0 {name=l4 lab=DM_2}
C {devices/lab_wire.sym} -765 90 2 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -765 170 0 1 {name=l6 lab=VB3}
C {devices/lab_wire.sym} -230 260 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 140 520 0 1 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 665 260 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 845 520 0 0 {name=l10 lab=VB3}
C {devices/lab_wire.sym} 1605 520 0 0 {name=l11 lab=VB3}
C {devices/lab_wire.sym} -330 90 2 0 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -330 170 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} -230 520 0 1 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 665 520 0 1 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1830 780 0 0 {name=l16 lab=VB4}
C {devices/lab_wire.sym} -10 260 0 1 {name=l17 lab=VINN}
C {devices/lab_wire.sym} 440 260 0 1 {name=l18 lab=VINN}
C {devices/lab_wire.sym} 215 260 0 1 {name=l19 lab=VINP}
C {devices/lab_wire.sym} 1830 260 0 0 {name=l20 lab=VINP}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l21 lab=VOUT}
C {devices/lab_wire.sym} -280 450 2 0 {name=l22 lab=VOUT}
C {devices/lab_wire.sym} 40 430 0 1 {name=l23 lab=VOUTN}
C {devices/lab_wire.sym} 215 0 0 1 {name=l24 lab=VOUTN}
C {devices/lab_wire.sym} 1265 0 0 0 {name=l25 lab=VOUTN}
C {devices/lab_wire.sym} 1365 350 2 0 {name=l26 lab=VOUTN}
C {devices/lab_wire.sym} 1605 0 0 0 {name=l27 lab=VOUTN}
C {devices/lab_wire.sym} 2150 350 2 0 {name=l28 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l29 lab=net013}
C {devices/lab_wire.sym} -885 0 0 1 {name=l30 lab=net013}
C {devices/lab_wire.sym} -665 0 0 1 {name=l31 lab=net013}
C {devices/lab_wire.sym} -450 0 0 1 {name=l32 lab=net013}
C {devices/lab_wire.sym} -290 60 2 0 {name=l33 lab=net013}
C {devices/lab_wire.sym} 340 90 2 0 {name=l34 lab=net043}
C {devices/lab_wire.sym} 340 350 2 0 {name=l35 lab=net043}
C {devices/lab_wire.sym} 340 430 0 1 {name=l36 lab=net043}
C {devices/lab_wire.sym} 1375 520 0 1 {name=l37 lab=net043}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l38 lab=net049}
C {devices/lab_wire.sym} 115 90 2 0 {name=l39 lab=net049}
C {devices/lab_wire.sym} 115 350 2 0 {name=l40 lab=net049}
C {devices/lab_wire.sym} 1275 430 0 1 {name=l41 lab=net049}
C {devices/lab_wire.sym} 1705 90 2 0 {name=l42 lab=net050}
C {devices/lab_wire.sym} 1705 170 0 1 {name=l43 lab=net050}
C {devices/lab_wire.sym} 1705 610 2 0 {name=l44 lab=net063}
C {devices/lab_wire.sym} 1930 350 2 0 {name=l45 lab=net063}
C {devices/lab_wire.sym} 1930 690 0 1 {name=l46 lab=net063}
C {devices/lab_wire.sym} -985 90 2 0 {name=l47 lab=net1}
C {devices/lab_wire.sym} 115 170 0 1 {name=l48 lab=net1}
C {devices/lab_wire.sym} 340 170 0 1 {name=l49 lab=net1}
C {devices/lab_wire.sym} 945 90 2 0 {name=l50 lab=net2}
C {devices/lab_wire.sym} 2150 90 2 0 {name=l51 lab=net3}
C {devices/lab_wire.sym} -550 90 2 0 {name=l52 lab=net31}
C {devices/lab_wire.sym} -110 170 0 1 {name=l53 lab=net31}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l54 lab=net4}
C {devices/lab_wire.sym} 440 0 0 1 {name=l55 lab=net4}
C {devices/lab_wire.sym} 1685 690 0 1 {name=l56 lab=net4}
C {devices/lab_wire.sym} 1705 350 2 0 {name=l57 lab=net4}
C {devices/lab_wire.sym} 1705 430 0 1 {name=l58 lab=net4}
C {devices/lab_wire.sym} 1365 90 2 0 {name=l59 lab=net5}
C {devices/lab_wire.sym} 1365 170 0 1 {name=l60 lab=net5}
C {devices/lab_wire.sym} -330 350 2 0 {name=l61 lab=net54}
C {devices/lab_wire.sym} 565 350 2 0 {name=l62 lab=net56}
C {devices/lab_wire.sym} 945 610 2 0 {name=l63 lab=net69}
C {devices/lab_wire.sym} -400 390 0 0 {name=l64 lab=net70}
C {devices/lab_wire.sym} 845 0 0 0 {name=l65 lab=net70}
C {devices/lab_wire.sym} 945 430 0 1 {name=l66 lab=net70}
C {devices/lab_wire.sym} 2110 -60 0 1 {name=l67 lab=net70}
C {devices/lab_wire.sym} 40 610 2 0 {name=l68 lab=net85}
C {devices/lab_wire.sym} 280 354 2 0 {name=l69 lab=net1}
C {devices/lab_wire.sym} 55 354 2 0 {name=l70 lab=net1}
C {devices/lab_wire.sym} -170 354 2 0 {name=l71 lab=net31}
C {devices/lab_wire.sym} 1990 354 2 0 {name=l72 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l73 lab=vdd}
C {devices/lab_wire.sym} -390 94 2 0 {name=l74 lab=vdd}
C {devices/lab_wire.sym} 280 94 2 0 {name=l75 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l76 lab=vdd}
C {devices/lab_wire.sym} 565 0 0 0 {name=l77 lab=vdd}
C {devices/lab_wire.sym} -825 94 2 0 {name=l78 lab=vdd}
C {devices/lab_wire.sym} -610 94 2 0 {name=l79 lab=vdd}
C {devices/lab_wire.sym} 1425 94 2 0 {name=l80 lab=vdd}
C {devices/lab_wire.sym} -1045 94 2 0 {name=l81 lab=vdd}
C {devices/lab_wire.sym} 1765 94 2 0 {name=l82 lab=vdd}
C {devices/lab_wire.sym} 1425 354 2 0 {name=l83 lab=vdd}
C {devices/lab_wire.sym} 1765 354 2 0 {name=l84 lab=vdd}
C {devices/lab_wire.sym} 2210 354 2 0 {name=l85 lab=vdd}
C {devices/lab_wire.sym} 1005 354 2 0 {name=l86 lab=vdd}
C {devices/lab_wire.sym} 1005 94 2 0 {name=l87 lab=vdd}
C {devices/lab_wire.sym} 2210 94 2 0 {name=l88 lab=vdd}
C {devices/lab_wire.sym} 55 94 2 0 {name=l89 lab=vdd}
C {devices/lab_wire.sym} -390 354 2 0 {name=l90 lab=vss}
C {devices/lab_wire.sym} 565 260 0 0 {name=l91 lab=vss}
C {devices/lab_wire.sym} -825 354 2 0 {name=l92 lab=vss}
C {devices/lab_wire.sym} 1955 520 0 0 {name=l93 lab=vss}
C {devices/lab_wire.sym} 1765 614 2 0 {name=l94 lab=vss}
C {devices/lab_wire.sym} -390 614 2 0 {name=l95 lab=vss}
C {devices/lab_wire.sym} 505 614 2 0 {name=l96 lab=vss}
C {devices/lab_wire.sym} 280 874 2 0 {name=l97 lab=vss}
C {devices/lab_wire.sym} 1990 874 2 0 {name=l98 lab=vss}
C {devices/lab_wire.sym} 280 614 2 0 {name=l99 lab=vss}
C {devices/lab_wire.sym} 1215 614 2 0 {name=l100 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l101 lab=vss}
C {devices/lab_wire.sym} -20 874 2 0 {name=l102 lab=vss}
C {devices/lab_wire.sym} 1005 874 2 0 {name=l103 lab=vss}
C {devices/lab_wire.sym} 1005 614 2 0 {name=l104 lab=vss}
C {devices/lab_wire.sym} -20 614 2 0 {name=l105 lab=vss}
C {devices/lab_wire.sym} -1915 870 2 0 {name=l106 lab=vss}
C {devices/lab_wire.sym} -1915 690 0 1 {name=l107 lab=net013}
C {devices/lab_wire.sym} 340 610 2 0 {name=l108 lab=vss}
C {devices/iopin.sym} -2030 -140 0 0 {name=p0 lab=vdd}
C {devices/iopin.sym} -2030 920 0 0 {name=p1 lab=vss}
B 8 -1646 -78 -240 78 {fill=0}
T {PMOS Simple Current Mirror (4 outputs)} -1646 -96 0 0 0.3 0.3 {layer=8}
B 10 -1225 182 1405 858 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror (3 outputs) [alt: cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode]} -1225 164 0 0 0.3 0.3 {layer=10}
B 12 129 -78 2610 338 {fill=0}
T {PMOS Improved High Swing Cascode Current Mirror (2 outputs) [alt: cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode]} 129 -96 0 0 0.3 0.3 {layer=12}
B 21 -120 442 1365 598 {fill=0}
T {NMOS Simple Current Mirror} -120 424 0 0 0.3 0.3 {layer=21}
B 15 -345 182 430 338 {fill=0}
T {PMOS Differential Pair} -345 164 0 0 0.3 0.3 {layer=15}
B 13 -546 182 2366 338 {fill=0}
T {PMOS Differential Pair} -546 164 0 0 0.3 0.3 {layer=13}
