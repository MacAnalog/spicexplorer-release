v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_009_leung_nmcnr} -1785 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1910 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} -590 260 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1745 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 335 260 1 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -680 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} 110 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -230 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 110 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 885 260 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 545 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1225 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1665 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 110 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 885 520 0 0 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 1225 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 885 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1665 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1020 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -230 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 545 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 330 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1225 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1665 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1450 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2145 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1745 430 -1745 490 {}
N -1745 550 -1745 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 660 {}
N -1340 190 -1340 260 {}
N -1100 60 -1100 230 {}
N -1100 260 -1100 354 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 90 {}
N -1040 290 -1040 660 {}
N -970 200 -970 260 {}
N -760 0 -760 94 {}
N -700 -140 -700 -30 {}
N -700 30 -700 70 {}
N -660 0 -660 70 {}
N -560 260 -560 320 {}
N -310 0 -310 94 {}
N -310 260 -310 354 {}
N -250 -140 -250 -30 {}
N -250 30 -250 230 {}
N -250 290 -250 660 {}
N 30 60 30 230 {}
N 30 260 30 354 {}
N 30 520 30 614 {}
N 90 -140 90 -30 {}
N 90 30 90 90 {}
N 90 290 90 490 {}
N 90 550 90 660 {}
N 160 -60 160 0 {}
N 220 230 220 520 {}
N 250 0 250 94 {}
N 310 -140 310 -30 {}
N 310 30 310 90 {}
N 335 200 335 260 {}
N 365 260 365 320 {}
N 380 -60 380 0 {}
N 495 -60 495 0 {}
N 505 30 505 200 {}
N 525 190 525 260 {}
N 565 -140 565 -30 {}
N 565 30 565 90 {}
N 565 190 565 230 {}
N 565 290 565 660 {}
N 625 0 625 94 {}
N 625 260 625 354 {}
N 835 -60 835 0 {}
N 835 520 835 580 {}
N 905 -140 905 -30 {}
N 905 30 905 90 {}
N 905 170 905 230 {}
N 905 290 905 490 {}
N 905 550 905 660 {}
N 965 0 965 94 {}
N 965 260 965 354 {}
N 965 520 965 614 {}
N 1175 520 1175 580 {}
N 1205 0 1205 70 {}
N 1245 -140 1245 -30 {}
N 1245 30 1245 70 {}
N 1245 170 1245 230 {}
N 1245 290 1245 490 {}
N 1245 550 1245 660 {}
N 1305 0 1305 94 {}
N 1305 260 1305 354 {}
N 1305 520 1305 614 {}
N 1470 200 1470 230 {}
N 1470 290 1470 320 {}
N 1530 60 1530 200 {}
N 1530 260 1530 354 {}
N 1685 -140 1685 -30 {}
N 1685 30 1685 90 {}
N 1685 170 1685 230 {}
N 1685 290 1685 490 {}
N 1685 550 1685 660 {}
N 1745 0 1745 94 {}
N 1745 260 1745 354 {}
N 1745 520 1745 614 {}
N 2165 200 2165 230 {}
N 2165 290 2165 320 {}
N 2225 260 2225 354 {}
N -1860 -140 2620 -140 {}
N 160 -60 380 -60 {}
N 495 -60 835 -60 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1000 0 -940 0 {}
N -760 0 -700 0 {}
N -660 0 -600 0 {}
N -310 0 -250 0 {}
N -210 0 -150 0 {}
N 130 0 190 0 {}
N 250 0 310 0 {}
N 350 0 525 0 {}
N 565 0 625 0 {}
N 835 0 865 0 {}
N 905 0 965 0 {}
N 1145 0 1205 0 {}
N 1245 0 1305 0 {}
N 1585 0 1645 0 {}
N 1685 0 1745 0 {}
N 505 30 565 30 {}
N -1100 60 -1040 60 {}
N 30 60 90 60 {}
N 310 60 1530 60 {}
N -700 70 -660 70 {}
N 1205 70 1245 70 {}
N -1380 190 -1340 190 {}
N 525 190 565 190 {}
N -1340 200 -970 200 {}
N -250 200 335 200 {}
N 505 200 565 200 {}
N 1410 200 2165 200 {}
N -1100 230 -1040 230 {}
N 30 230 220 230 {}
N -1440 260 -1380 260 {}
N -1100 260 -1040 260 {}
N -1000 260 -970 260 {}
N -680 260 -620 260 {}
N -560 260 -530 260 {}
N -310 260 -250 260 {}
N -210 260 -150 260 {}
N 30 260 90 260 {}
N 130 260 190 260 {}
N 275 260 335 260 {}
N 365 260 395 260 {}
N 565 260 625 260 {}
N 805 260 865 260 {}
N 905 260 965 260 {}
N 1145 260 1205 260 {}
N 1245 260 1305 260 {}
N 1340 260 1430 260 {}
N 1470 260 1530 260 {}
N 1585 260 1645 260 {}
N 1685 260 1745 260 {}
N 1820 260 1880 260 {}
N 1940 260 1970 260 {}
N 2035 260 2125 260 {}
N 2165 260 2225 260 {}
N 1245 320 1470 320 {}
N 1685 320 2165 320 {}
N 30 520 90 520 {}
N 130 520 865 520 {}
N 905 520 965 520 {}
N 1175 520 1205 520 {}
N 1245 520 1305 520 {}
N 1585 520 1645 520 {}
N 1685 520 1745 520 {}
N 835 580 1175 580 {}
N -1860 660 2620 660 {}
C {devices/lab_wire.sym} 905 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 905 170 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 1245 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} 190 260 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 565 90 2 0 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 805 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 1145 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 1585 260 0 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 90 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} 1585 520 0 0 {name=l9 lab=VB4}
C {devices/lab_wire.sym} -250 90 2 0 {name=l10 lab=VOUT}
C {devices/lab_wire.sym} 1145 0 0 0 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} 1245 170 0 1 {name=l12 lab=VOUTN}
C {devices/lab_wire.sym} 1585 0 0 0 {name=l13 lab=VOUTN}
C {devices/lab_wire.sym} -940 0 0 1 {name=l14 lab=net013}
C {devices/lab_wire.sym} -600 0 0 1 {name=l15 lab=net013}
C {devices/lab_wire.sym} -150 0 0 1 {name=l16 lab=net013}
C {devices/lab_wire.sym} 190 0 0 1 {name=l17 lab=net013}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l18 lab=net043}
C {devices/lab_wire.sym} -560 320 2 0 {name=l19 lab=net044}
C {devices/lab_wire.sym} 365 320 2 0 {name=l20 lab=net044}
C {devices/lab_wire.sym} 1820 260 0 0 {name=l21 lab=net044}
C {devices/lab_wire.sym} -1040 90 2 0 {name=l22 lab=net049}
C {devices/lab_wire.sym} -680 260 0 0 {name=l23 lab=net049}
C {devices/lab_wire.sym} -150 260 0 1 {name=l24 lab=net049}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l25 lab=net050}
C {devices/lab_wire.sym} 1685 90 2 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1685 170 0 1 {name=l27 lab=net050}
C {devices/lab_wire.sym} 1940 260 0 0 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1685 350 2 0 {name=l29 lab=net063}
C {devices/lab_wire.sym} 310 90 2 0 {name=l30 lab=net31}
C {devices/lab_wire.sym} 90 350 2 0 {name=l31 lab=net54}
C {devices/lab_wire.sym} 905 350 2 0 {name=l32 lab=net56}
C {devices/lab_wire.sym} 1530 354 2 0 {name=l33 lab=net31}
C {devices/lab_wire.sym} 2225 354 2 0 {name=l34 lab=net31}
C {devices/lab_wire.sym} -760 94 2 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} 90 0 0 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} -310 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} 965 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 625 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 250 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} 1305 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 1745 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -1040 0 0 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 30 354 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 965 354 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} 625 354 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} 1305 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 1745 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} 30 614 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} 965 614 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} 1305 614 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} 1745 614 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} -1100 354 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} -310 354 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} -1745 430 0 1 {name=l57 lab=net013}
C {devices/lab_wire.sym} -1745 610 2 0 {name=l58 lab=vss}
C {devices/ipin.sym} 1340 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2035 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1860 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1860 660 0 0 {name=p3 lab=vss}
