v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_016_song_dacfc} -1910 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -510 390 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 295 780 0 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1870 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 0 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -510 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -170 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1465 520 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 295 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -510 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -170 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 0 780 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 580 780 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 0 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -800 520 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 1050 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1465 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 0 260 0 0 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} 1050 260 0 0 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} 1235 0 0 0 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 295 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 1465 260 0 0 {name=M60 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm60_w l=x_dut_xm60_l m=x_dut_xm60_m}
C {devices/sg13_lv_pmos_np.sym} 295 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 1805 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_pmos_np.sym} 760 260 0 0 {name=M63 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 1100 780 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_nmos_np.sym} 760 780 0 0 {name=M65 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 760 0 0 0 {name=M68 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_pmos_np.sym} 1805 0 0 0 {name=M69 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 2035 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 760 520 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_nmos_np.sym} 1100 520 0 0 {name=M71 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm71_w l=x_dut_xm71_l m=x_dut_xm71_m}
C {devices/sg13_lv_pmos_np.sym} 1235 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 580 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1870 690 -1870 750 {}
N -1870 810 -1870 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 920 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 920 {}
N -830 190 -830 260 {}
N -800 0 -800 60 {}
N -780 260 -780 490 {}
N -780 550 -780 920 {}
N -720 520 -720 614 {}
N -590 0 -590 94 {}
N -590 260 -590 354 {}
N -590 520 -590 614 {}
N -530 -140 -530 -30 {}
N -530 30 -530 90 {}
N -530 170 -530 230 {}
N -530 290 -530 350 {}
N -530 430 -530 490 {}
N -530 550 -530 920 {}
N -480 390 -480 450 {}
N -250 0 -250 94 {}
N -250 260 -250 354 {}
N -250 520 -250 614 {}
N -190 -140 -190 -30 {}
N -190 30 -190 230 {}
N -190 290 -190 350 {}
N -190 430 -190 490 {}
N -190 550 -190 920 {}
N -150 0 -150 70 {}
N -150 260 -150 320 {}
N -150 520 -150 580 {}
N -50 520 -50 780 {}
N -20 -60 -20 0 {}
N -20 200 -20 260 {}
N -20 450 -20 520 {}
N 20 -140 20 -30 {}
N 20 30 20 90 {}
N 20 170 20 230 {}
N 20 290 20 350 {}
N 20 430 20 490 {}
N 20 550 20 610 {}
N 20 690 20 750 {}
N 20 810 20 920 {}
N 80 0 80 94 {}
N 80 260 80 354 {}
N 80 520 80 614 {}
N 80 780 80 874 {}
N 215 0 215 94 {}
N 215 260 215 354 {}
N 215 520 215 614 {}
N 275 -140 275 -30 {}
N 275 30 275 90 {}
N 275 170 275 230 {}
N 275 290 275 350 {}
N 275 430 275 490 {}
N 275 550 275 610 {}
N 295 690 295 750 {}
N 295 810 295 920 {}
N 315 260 315 320 {}
N 500 260 500 354 {}
N 500 780 500 874 {}
N 560 170 560 230 {}
N 560 290 560 350 {}
N 560 690 560 750 {}
N 560 810 560 920 {}
N 600 260 600 320 {}
N 600 780 600 840 {}
N 740 200 740 260 {}
N 780 -140 780 -30 {}
N 780 30 780 90 {}
N 780 170 780 230 {}
N 780 290 780 350 {}
N 780 430 780 490 {}
N 780 550 780 610 {}
N 780 690 780 750 {}
N 780 810 780 920 {}
N 840 0 840 94 {}
N 840 260 840 354 {}
N 840 520 840 614 {}
N 840 780 840 874 {}
N 1030 -60 1030 0 {}
N 1030 200 1030 260 {}
N 1070 -140 1070 -30 {}
N 1070 30 1070 90 {}
N 1070 170 1070 230 {}
N 1070 290 1070 460 {}
N 1120 430 1120 490 {}
N 1120 550 1120 610 {}
N 1120 690 1120 750 {}
N 1120 810 1120 920 {}
N 1130 0 1130 94 {}
N 1130 260 1130 354 {}
N 1180 520 1180 614 {}
N 1180 780 1180 874 {}
N 1215 -60 1215 0 {}
N 1215 200 1215 260 {}
N 1255 -140 1255 -30 {}
N 1255 30 1255 90 {}
N 1255 170 1255 230 {}
N 1255 290 1255 350 {}
N 1315 0 1315 94 {}
N 1315 260 1315 354 {}
N 1445 -60 1445 0 {}
N 1445 200 1445 260 {}
N 1485 -140 1485 -30 {}
N 1485 30 1485 230 {}
N 1485 290 1485 350 {}
N 1485 460 1485 490 {}
N 1485 550 1485 610 {}
N 1545 0 1545 94 {}
N 1545 260 1545 354 {}
N 1545 520 1545 614 {}
N 1825 -140 1825 -30 {}
N 1825 30 1825 230 {}
N 1825 290 1825 350 {}
N 1885 0 1885 94 {}
N 1885 260 1885 354 {}
N 2015 -60 2015 0 {}
N 2055 -140 2055 -30 {}
N 2055 30 2055 320 {}
N 2115 0 2115 94 {}
N -1930 -140 2245 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -490 0 -430 0 {}
N -250 0 -190 0 {}
N -50 0 -20 0 {}
N 20 0 80 0 {}
N 215 0 275 0 {}
N 315 0 375 0 {}
N 680 0 740 0 {}
N 780 0 840 0 {}
N 1000 0 1030 0 {}
N 1070 0 1130 0 {}
N 1185 0 1215 0 {}
N 1255 0 1315 0 {}
N 1415 0 1445 0 {}
N 1485 0 1545 0 {}
N 1725 0 1785 0 {}
N 1825 0 1885 0 {}
N 1985 0 2015 0 {}
N 2055 0 2115 0 {}
N -1210 70 -1170 70 {}
N -190 70 -150 70 {}
N -870 190 -830 190 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -930 260 -870 260 {}
N -590 260 -530 260 {}
N -490 260 -430 260 {}
N -250 260 -190 260 {}
N -150 260 -120 260 {}
N -50 260 -20 260 {}
N 20 260 80 260 {}
N 215 260 275 260 {}
N 500 260 560 260 {}
N 600 260 630 260 {}
N 780 260 840 260 {}
N 1000 260 1030 260 {}
N 1070 260 1130 260 {}
N 1185 260 1215 260 {}
N 1255 260 1315 260 {}
N 1415 260 1445 260 {}
N 1485 260 1545 260 {}
N 1725 260 1785 260 {}
N 1825 260 1885 260 {}
N -600 390 -540 390 {}
N -480 390 710 390 {}
N -20 450 20 450 {}
N 1120 460 1485 460 {}
N -880 520 -820 520 {}
N -780 520 -720 520 {}
N -590 520 -530 520 {}
N -490 520 -430 520 {}
N -250 520 -190 520 {}
N -150 520 -50 520 {}
N 20 520 80 520 {}
N 215 520 275 520 {}
N 315 520 740 520 {}
N 780 520 840 520 {}
N 1020 520 1080 520 {}
N 1120 520 1180 520 {}
N 1385 520 1445 520 {}
N 1485 520 1545 520 {}
N 275 580 560 580 {}
N -50 780 -20 780 {}
N 20 780 80 780 {}
N 500 780 560 780 {}
N 600 780 740 780 {}
N 780 780 840 780 {}
N 1020 780 1080 780 {}
N 1120 780 1180 780 {}
N -1930 920 2245 920 {}
C {devices/lab_wire.sym} -1930 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -1930 920 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} -150 60 2 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} 315 320 2 0 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 740 200 0 1 {name=l4 lab=DM_1}
C {devices/lab_wire.sym} 1445 200 0 1 {name=l5 lab=DM_1}
C {devices/lab_wire.sym} 1725 260 0 0 {name=l6 lab=DM_1}
C {devices/lab_wire.sym} 20 690 0 1 {name=l7 lab=DM_2}
C {devices/lab_wire.sym} 1255 350 2 0 {name=l8 lab=DM_2}
C {devices/lab_wire.sym} 1485 610 2 0 {name=l9 lab=DM_2}
C {devices/lab_wire.sym} -870 90 2 0 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -870 170 0 1 {name=l11 lab=VB3}
C {devices/lab_wire.sym} -430 260 0 1 {name=l12 lab=VB3}
C {devices/lab_wire.sym} -150 320 2 0 {name=l13 lab=VB3}
C {devices/lab_wire.sym} 375 520 0 1 {name=l14 lab=VB3}
C {devices/lab_wire.sym} 1020 520 0 0 {name=l15 lab=VB3}
C {devices/lab_wire.sym} 1385 520 0 0 {name=l16 lab=VB3}
C {devices/lab_wire.sym} -530 90 2 0 {name=l17 lab=VB4}
C {devices/lab_wire.sym} -530 170 0 1 {name=l18 lab=VB4}
C {devices/lab_wire.sym} -430 520 0 1 {name=l19 lab=VB4}
C {devices/lab_wire.sym} -150 580 2 0 {name=l20 lab=VB4}
C {devices/lab_wire.sym} 600 840 2 0 {name=l21 lab=VB4}
C {devices/lab_wire.sym} 1020 780 0 0 {name=l22 lab=VB4}
C {devices/lab_wire.sym} -20 200 0 1 {name=l23 lab=VINN}
C {devices/lab_wire.sym} 1215 200 0 1 {name=l24 lab=VINN}
C {devices/lab_wire.sym} 600 320 2 0 {name=l25 lab=VINP}
C {devices/lab_wire.sym} 1030 200 0 1 {name=l26 lab=VINP}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l27 lab=VOUT}
C {devices/lab_wire.sym} -600 390 0 0 {name=l28 lab=VOUT}
C {devices/lab_wire.sym} 375 0 0 1 {name=l29 lab=VOUTN}
C {devices/lab_wire.sym} 1120 430 0 1 {name=l30 lab=VOUTN}
C {devices/lab_wire.sym} 1445 -60 0 1 {name=l31 lab=VOUTN}
C {devices/lab_wire.sym} 1485 350 2 0 {name=l32 lab=VOUTN}
C {devices/lab_wire.sym} 1825 350 2 0 {name=l33 lab=VOUTN}
C {devices/lab_wire.sym} 2015 -60 0 1 {name=l34 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l35 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l36 lab=net013}
C {devices/lab_wire.sym} -430 0 0 1 {name=l37 lab=net013}
C {devices/lab_wire.sym} 1030 -60 0 1 {name=l38 lab=net013}
C {devices/lab_wire.sym} 1215 -60 0 1 {name=l39 lab=net013}
C {devices/lab_wire.sym} -880 520 0 0 {name=l40 lab=net043}
C {devices/lab_wire.sym} 20 430 0 1 {name=l41 lab=net043}
C {devices/lab_wire.sym} 20 90 2 0 {name=l42 lab=net043}
C {devices/lab_wire.sym} 20 350 2 0 {name=l43 lab=net043}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l44 lab=net049}
C {devices/lab_wire.sym} -780 430 0 1 {name=l45 lab=net049}
C {devices/lab_wire.sym} 1070 350 2 0 {name=l46 lab=net049}
C {devices/lab_wire.sym} 2055 90 2 0 {name=l47 lab=net049}
C {devices/lab_wire.sym} 275 90 2 0 {name=l48 lab=net050}
C {devices/lab_wire.sym} 275 170 0 1 {name=l49 lab=net050}
C {devices/lab_wire.sym} 275 610 2 0 {name=l50 lab=net063}
C {devices/lab_wire.sym} 560 350 2 0 {name=l51 lab=net063}
C {devices/lab_wire.sym} 560 690 0 1 {name=l52 lab=net063}
C {devices/lab_wire.sym} 20 170 0 1 {name=l53 lab=net1}
C {devices/lab_wire.sym} 1070 170 0 1 {name=l54 lab=net1}
C {devices/lab_wire.sym} 1255 90 2 0 {name=l55 lab=net1}
C {devices/lab_wire.sym} 780 90 2 0 {name=l56 lab=net2}
C {devices/lab_wire.sym} 780 170 0 1 {name=l57 lab=net2}
C {devices/lab_wire.sym} 1825 90 2 0 {name=l58 lab=net3}
C {devices/lab_wire.sym} 560 170 0 1 {name=l59 lab=net31}
C {devices/lab_wire.sym} 1070 90 2 0 {name=l60 lab=net31}
C {devices/lab_wire.sym} 1255 170 0 1 {name=l61 lab=net31}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l62 lab=net4}
C {devices/lab_wire.sym} -20 -60 0 1 {name=l63 lab=net4}
C {devices/lab_wire.sym} 275 350 2 0 {name=l64 lab=net4}
C {devices/lab_wire.sym} 275 430 0 1 {name=l65 lab=net4}
C {devices/lab_wire.sym} 295 690 0 1 {name=l66 lab=net4}
C {devices/lab_wire.sym} 1485 90 2 0 {name=l67 lab=net5}
C {devices/lab_wire.sym} -530 350 2 0 {name=l68 lab=net54}
C {devices/lab_wire.sym} -530 430 0 1 {name=l69 lab=net54}
C {devices/lab_wire.sym} -190 350 2 0 {name=l70 lab=net56}
C {devices/lab_wire.sym} -190 430 0 1 {name=l71 lab=net56}
C {devices/lab_wire.sym} 780 610 2 0 {name=l72 lab=net69}
C {devices/lab_wire.sym} 780 690 0 1 {name=l73 lab=net69}
C {devices/lab_wire.sym} -480 450 2 0 {name=l74 lab=net70}
C {devices/lab_wire.sym} 680 0 0 0 {name=l75 lab=net70}
C {devices/lab_wire.sym} 780 350 2 0 {name=l76 lab=net70}
C {devices/lab_wire.sym} 780 430 0 1 {name=l77 lab=net70}
C {devices/lab_wire.sym} 1725 0 0 0 {name=l78 lab=net70}
C {devices/lab_wire.sym} 1120 610 2 0 {name=l79 lab=net85}
C {devices/lab_wire.sym} 1120 690 0 1 {name=l80 lab=net85}
C {devices/lab_wire.sym} 80 354 2 0 {name=l81 lab=net1}
C {devices/lab_wire.sym} 1130 354 2 0 {name=l82 lab=net1}
C {devices/lab_wire.sym} 1315 354 2 0 {name=l83 lab=net31}
C {devices/lab_wire.sym} 500 354 2 0 {name=l84 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l85 lab=vdd}
C {devices/lab_wire.sym} -590 94 2 0 {name=l86 lab=vdd}
C {devices/lab_wire.sym} 80 94 2 0 {name=l87 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l88 lab=vdd}
C {devices/lab_wire.sym} -250 94 2 0 {name=l89 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l90 lab=vdd}
C {devices/lab_wire.sym} 1130 94 2 0 {name=l91 lab=vdd}
C {devices/lab_wire.sym} 1545 94 2 0 {name=l92 lab=vdd}
C {devices/lab_wire.sym} 1315 94 2 0 {name=l93 lab=vdd}
C {devices/lab_wire.sym} 215 94 2 0 {name=l94 lab=vdd}
C {devices/lab_wire.sym} 1545 354 2 0 {name=l95 lab=vdd}
C {devices/lab_wire.sym} 215 354 2 0 {name=l96 lab=vdd}
C {devices/lab_wire.sym} 1885 354 2 0 {name=l97 lab=vdd}
C {devices/lab_wire.sym} 840 354 2 0 {name=l98 lab=vdd}
C {devices/lab_wire.sym} 840 94 2 0 {name=l99 lab=vdd}
C {devices/lab_wire.sym} 1885 94 2 0 {name=l100 lab=vdd}
C {devices/lab_wire.sym} 2115 94 2 0 {name=l101 lab=vdd}
C {devices/lab_wire.sym} -590 354 2 0 {name=l102 lab=vss}
C {devices/lab_wire.sym} -250 354 2 0 {name=l103 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l104 lab=vss}
C {devices/lab_wire.sym} 1545 614 2 0 {name=l105 lab=vss}
C {devices/lab_wire.sym} 215 614 2 0 {name=l106 lab=vss}
C {devices/lab_wire.sym} -590 614 2 0 {name=l107 lab=vss}
C {devices/lab_wire.sym} -250 614 2 0 {name=l108 lab=vss}
C {devices/lab_wire.sym} 80 874 2 0 {name=l109 lab=vss}
C {devices/lab_wire.sym} 500 874 2 0 {name=l110 lab=vss}
C {devices/lab_wire.sym} 80 614 2 0 {name=l111 lab=vss}
C {devices/lab_wire.sym} -720 614 2 0 {name=l112 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l113 lab=vss}
C {devices/lab_wire.sym} 1180 874 2 0 {name=l114 lab=vss}
C {devices/lab_wire.sym} 840 874 2 0 {name=l115 lab=vss}
C {devices/lab_wire.sym} 840 614 2 0 {name=l116 lab=vss}
C {devices/lab_wire.sym} 1180 614 2 0 {name=l117 lab=vss}
C {devices/lab_wire.sym} -1870 870 2 0 {name=l118 lab=vss}
C {devices/lab_wire.sym} -1870 690 0 1 {name=l119 lab=net013}
C {devices/lab_wire.sym} 20 610 2 0 {name=l120 lab=vss}
