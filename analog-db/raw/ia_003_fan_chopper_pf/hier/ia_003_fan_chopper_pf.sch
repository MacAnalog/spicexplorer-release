v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ia_003_fan_chopper_pf} -6905 -540 0 0 0.4 0.4 {}
C {blocks/tg_pair_cmos_rail_bulk_1.sym} -6645 0 0 0 {name=xtg_pair_cmos_rail_bulk_1}
C {blocks/tg_pair_cmos_rail_bulk_2.sym} -6145 0 0 0 {name=xtg_pair_cmos_rail_bulk_2}
C {blocks/dp_pmos_simple_1.sym} -5675 0 0 0 {name=xdp_pmos_simple_1}
C {blocks/tg_pair_cmos_rail_bulk_3.sym} -5205 0 0 0 {name=xtg_pair_cmos_rail_bulk_3}
C {blocks/dp_nmos_simple_1.sym} -4735 0 0 0 {name=xdp_nmos_simple_1}
C {blocks/dp_nmos_simple_2.sym} -4295 0 0 0 {name=xdp_nmos_simple_2}
C {blocks/dp_nmos_simple_3.sym} -3855 0 0 0 {name=xdp_nmos_simple_3}
C {blocks/tg_pair_cmos_rail_bulk_4.sym} -3385 0 0 0 {name=xtg_pair_cmos_rail_bulk_4}
C {blocks/dp_nmos_simple_4.sym} -2915 0 0 0 {name=xdp_nmos_simple_4}
C {blocks/dp_nmos_simple_5.sym} -2475 0 0 0 {name=xdp_nmos_simple_5}
C {blocks/dp_nmos_simple_6.sym} -2035 0 0 0 {name=xdp_nmos_simple_6}
C {blocks/tg_pair_cmos_rail_bulk_5.sym} -1565 0 0 0 {name=xtg_pair_cmos_rail_bulk_5}
C {blocks/tg_pair_cmos_rail_bulk_6.sym} -1065 0 0 0 {name=xtg_pair_cmos_rail_bulk_6}
C {blocks/tg_pair_cmos_rail_bulk_7.sym} -565 0 0 0 {name=xtg_pair_cmos_rail_bulk_7}
C {blocks/dp_nmos_simple_7.sym} -95 0 0 0 {name=xdp_nmos_simple_7}
C {blocks/dp_nmos_simple_8.sym} 345 0 0 0 {name=xdp_nmos_simple_8}
C {blocks/tg_pair_cmos_rail_bulk_8.sym} 815 0 0 0 {name=xtg_pair_cmos_rail_bulk_8}
C {blocks/dp_nmos_simple_9.sym} 1285 0 0 0 {name=xdp_nmos_simple_9}
C {blocks/dp_nmos_simple_10.sym} 1725 0 0 0 {name=xdp_nmos_simple_10}
C {blocks/tg_pair_cmos_rail_bulk_9.sym} 2195 0 0 0 {name=xtg_pair_cmos_rail_bulk_9}
C {blocks/tg_pair_cmos_rail_bulk_10.sym} 2700 0 0 0 {name=xtg_pair_cmos_rail_bulk_10}
C {blocks/tg_pair_cmos_rail_bulk_11.sym} 3210 0 0 0 {name=xtg_pair_cmos_rail_bulk_11}
C {blocks/tg_pair_cmos_rail_bulk_12.sym} 3720 0 0 0 {name=xtg_pair_cmos_rail_bulk_12}
C {blocks/tg_pair_cmos_rail_bulk_13.sym} 4230 0 0 0 {name=xtg_pair_cmos_rail_bulk_13}
C {blocks/dp_nmos_simple_11.sym} 4705 0 0 0 {name=xdp_nmos_simple_11}
C {blocks/tg_pair_cmos_rail_bulk_14.sym} 5180 0 0 0 {name=xtg_pair_cmos_rail_bulk_14}
C {blocks/dp_nmos_simple_12.sym} 5655 0 0 0 {name=xdp_nmos_simple_12}
C {blocks/tg_pair_cmos_rail_bulk_15.sym} 6130 0 0 0 {name=xtg_pair_cmos_rail_bulk_15}
C {blocks/tg_pair_cmos_rail_bulk_16.sym} 6640 0 0 0 {name=xtg_pair_cmos_rail_bulk_16}
C {devices/capa_np.sym} -1650 340 0 0 {name=CFB1 value='x_dut_cfb1_value'}
C {devices/capa_np.sym} -1430 340 0 0 {name=CFB2 value='x_dut_cfb2_value'}
C {devices/capa_np.sym} -1210 340 0 0 {name=CIN1 value='x_dut_cin1_value'}
C {devices/capa_np.sym} -990 340 0 0 {name=CIN2 value='x_dut_cin2_value'}
C {devices/capa_np.sym} -770 340 0 0 {name=CM1 value='x_dut_cm1_value'}
C {devices/capa_np.sym} -550 340 0 0 {name=CM2 value='x_dut_cm2_value'}
C {devices/capa_np.sym} -330 340 0 0 {name=CPF1 value='x_dut_cpf1_value'}
C {devices/capa_np.sym} -110 340 0 0 {name=CPF2 value='x_dut_cpf2_value'}
C {devices/res_np.sym} 110 340 0 0 {name=RB1 value='x_dut_rb1_value'}
C {devices/res_np.sym} 330 340 0 0 {name=RB2 value='x_dut_rb2_value'}
C {devices/vsource_np.sym} -6865 340 0 0 {name=VB1 value="dc {vb1}"}
C {devices/vsource_np.sym} -6865 120 0 0 {name=VB2 value="dc {vb2}"}
C {devices/vsource_np.sym} -6865 -100 0 0 {name=VB3 value="dc {vb3}"}
C {devices/vsource_np.sym} -6865 -320 0 0 {name=VB4 value="dc {vb4}"}
C {devices/sg13_lv_pmos_np.sym} -660 -340 0 0 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -440 -340 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -220 -340 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 550 340 0 0 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 770 340 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 990 340 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1210 340 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1430 340 0 0 {name=M4 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_nmos_np.sym} 1650 340 0 0 {name=M5 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 0 -340 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 220 -340 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 440 -340 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 660 -340 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -6785 -20 -6825 -20 {}
C {devices/lab_wire.sym} -6825 -20 0 0 {name=l0 lab=clk_chout}
N -6785 20 -6825 20 {}
C {devices/lab_wire.sym} -6825 20 0 0 {name=l1 lab=clk_chout_not}
N -6505 -20 -6465 -20 {}
C {devices/lab_wire.sym} -6465 -20 0 1 {name=l2 lab=g2_n}
N -6505 20 -6465 20 {}
C {devices/lab_wire.sym} -6465 20 0 1 {name=l3 lab=out1_n}
N -6645 -80 -6645 -120 {}
C {devices/lab_wire.sym} -6645 -120 0 1 {name=l4 lab=vdd}
N -6645 80 -6645 120 {}
C {devices/lab_wire.sym} -6645 120 2 0 {name=l5 lab=vss}
N -6285 -20 -6325 -20 {}
C {devices/lab_wire.sym} -6325 -20 0 0 {name=l6 lab=clk_chout}
N -6285 20 -6325 20 {}
C {devices/lab_wire.sym} -6325 20 0 0 {name=l7 lab=clk_chout_not}
N -6005 -20 -5965 -20 {}
C {devices/lab_wire.sym} -5965 -20 0 1 {name=l8 lab=g2_p}
N -6005 20 -5965 20 {}
C {devices/lab_wire.sym} -5965 20 0 1 {name=l9 lab=out1_p}
N -6145 -80 -6145 -120 {}
C {devices/lab_wire.sym} -6145 -120 0 1 {name=l10 lab=vdd}
N -6145 80 -6145 120 {}
C {devices/lab_wire.sym} -6145 120 2 0 {name=l11 lab=vss}
N -5785 -20 -5825 -20 {}
C {devices/lab_wire.sym} -5825 -20 0 0 {name=l12 lab=vsum_n}
N -5785 20 -5825 20 {}
C {devices/lab_wire.sym} -5825 20 0 0 {name=l13 lab=vsum_p}
N -5565 -40 -5525 -40 {}
C {devices/lab_wire.sym} -5525 -40 0 1 {name=l14 lab=fold_n}
N -5565 0 -5525 0 {}
C {devices/lab_wire.sym} -5525 0 0 1 {name=l15 lab=fold_p}
N -5565 40 -5525 40 {}
C {devices/lab_wire.sym} -5525 40 0 1 {name=l16 lab=tail}
N -5675 -100 -5675 -140 {}
C {devices/lab_wire.sym} -5675 -140 0 1 {name=l17 lab=vdd}
N -5345 -20 -5385 -20 {}
C {devices/lab_wire.sym} -5385 -20 0 0 {name=l18 lab=clk_chfb}
N -5345 20 -5385 20 {}
C {devices/lab_wire.sym} -5385 20 0 0 {name=l19 lab=clk_chfb_not}
N -5065 -20 -5025 -20 {}
C {devices/lab_wire.sym} -5025 -20 0 1 {name=l20 lab=fbch_p}
N -5065 20 -5025 20 {}
C {devices/lab_wire.sym} -5025 20 0 1 {name=l21 lab=voutp}
N -5205 -80 -5205 -120 {}
C {devices/lab_wire.sym} -5205 -120 0 1 {name=l22 lab=vdd}
N -5205 80 -5205 120 {}
C {devices/lab_wire.sym} -5205 120 2 0 {name=l23 lab=vss}
N -4845 -20 -4885 -20 {}
C {devices/lab_wire.sym} -4885 -20 0 0 {name=l24 lab=clk_chfb}
N -4845 20 -4885 20 {}
C {devices/lab_wire.sym} -4885 20 0 0 {name=l25 lab=clk_chpf}
N -4625 -40 -4585 -40 {}
C {devices/lab_wire.sym} -4585 -40 0 1 {name=l26 lab=fbch_p}
N -4625 0 -4585 0 {}
C {devices/lab_wire.sym} -4585 0 0 1 {name=l27 lab=pfch_p}
N -4625 40 -4585 40 {}
C {devices/lab_wire.sym} -4585 40 0 1 {name=l28 lab=voutp}
N -4735 100 -4735 140 {}
C {devices/lab_wire.sym} -4735 140 2 0 {name=l29 lab=vss}
N -4405 -20 -4445 -20 {}
C {devices/lab_wire.sym} -4445 -20 0 0 {name=l30 lab=clk_chfb}
N -4405 20 -4445 20 {}
C {devices/lab_wire.sym} -4445 20 0 0 {name=l31 lab=clk_chfb_not}
N -4185 -40 -4145 -40 {}
C {devices/lab_wire.sym} -4145 -40 0 1 {name=l32 lab=fbch_n}
N -4185 0 -4145 0 {}
C {devices/lab_wire.sym} -4145 0 0 1 {name=l33 lab=fbch_p}
N -4185 40 -4145 40 {}
C {devices/lab_wire.sym} -4145 40 0 1 {name=l34 lab=voutp}
N -4295 100 -4295 140 {}
C {devices/lab_wire.sym} -4295 140 2 0 {name=l35 lab=vss}
N -3965 -20 -4005 -20 {}
C {devices/lab_wire.sym} -4005 -20 0 0 {name=l36 lab=clk_chfb}
N -3965 20 -4005 20 {}
C {devices/lab_wire.sym} -4005 20 0 0 {name=l37 lab=clk_chpf_not}
N -3745 -40 -3705 -40 {}
C {devices/lab_wire.sym} -3705 -40 0 1 {name=l38 lab=fbch_p}
N -3745 0 -3705 0 {}
C {devices/lab_wire.sym} -3705 0 0 1 {name=l39 lab=pfch_n}
N -3745 40 -3705 40 {}
C {devices/lab_wire.sym} -3705 40 0 1 {name=l40 lab=voutp}
N -3855 100 -3855 140 {}
C {devices/lab_wire.sym} -3855 140 2 0 {name=l41 lab=vss}
N -3525 -20 -3565 -20 {}
C {devices/lab_wire.sym} -3565 -20 0 0 {name=l42 lab=clk_chfb}
N -3525 20 -3565 20 {}
C {devices/lab_wire.sym} -3565 20 0 0 {name=l43 lab=clk_chfb_not}
N -3245 -20 -3205 -20 {}
C {devices/lab_wire.sym} -3205 -20 0 1 {name=l44 lab=fbch_n}
N -3245 20 -3205 20 {}
C {devices/lab_wire.sym} -3205 20 0 1 {name=l45 lab=voutn}
N -3385 -80 -3385 -120 {}
C {devices/lab_wire.sym} -3385 -120 0 1 {name=l46 lab=vdd}
N -3385 80 -3385 120 {}
C {devices/lab_wire.sym} -3385 120 2 0 {name=l47 lab=vss}
N -3025 -20 -3065 -20 {}
C {devices/lab_wire.sym} -3065 -20 0 0 {name=l48 lab=clk_chfb}
N -3025 20 -3065 20 {}
C {devices/lab_wire.sym} -3065 20 0 0 {name=l49 lab=clk_chpf}
N -2805 -40 -2765 -40 {}
C {devices/lab_wire.sym} -2765 -40 0 1 {name=l50 lab=fbch_n}
N -2805 0 -2765 0 {}
C {devices/lab_wire.sym} -2765 0 0 1 {name=l51 lab=pfch_n}
N -2805 40 -2765 40 {}
C {devices/lab_wire.sym} -2765 40 0 1 {name=l52 lab=voutn}
N -2915 100 -2915 140 {}
C {devices/lab_wire.sym} -2915 140 2 0 {name=l53 lab=vss}
N -2585 -20 -2625 -20 {}
C {devices/lab_wire.sym} -2625 -20 0 0 {name=l54 lab=clk_chfb}
N -2585 20 -2625 20 {}
C {devices/lab_wire.sym} -2625 20 0 0 {name=l55 lab=clk_chfb_not}
N -2365 -40 -2325 -40 {}
C {devices/lab_wire.sym} -2325 -40 0 1 {name=l56 lab=fbch_n}
N -2365 0 -2325 0 {}
C {devices/lab_wire.sym} -2325 0 0 1 {name=l57 lab=fbch_p}
N -2365 40 -2325 40 {}
C {devices/lab_wire.sym} -2325 40 0 1 {name=l58 lab=voutn}
N -2475 100 -2475 140 {}
C {devices/lab_wire.sym} -2475 140 2 0 {name=l59 lab=vss}
N -2145 -20 -2185 -20 {}
C {devices/lab_wire.sym} -2185 -20 0 0 {name=l60 lab=clk_chfb}
N -2145 20 -2185 20 {}
C {devices/lab_wire.sym} -2185 20 0 0 {name=l61 lab=clk_chpf_not}
N -1925 -40 -1885 -40 {}
C {devices/lab_wire.sym} -1885 -40 0 1 {name=l62 lab=fbch_n}
N -1925 0 -1885 0 {}
C {devices/lab_wire.sym} -1885 0 0 1 {name=l63 lab=pfch_p}
N -1925 40 -1885 40 {}
C {devices/lab_wire.sym} -1885 40 0 1 {name=l64 lab=voutn}
N -2035 100 -2035 140 {}
C {devices/lab_wire.sym} -2035 140 2 0 {name=l65 lab=vss}
N -1705 -20 -1745 -20 {}
C {devices/lab_wire.sym} -1745 -20 0 0 {name=l66 lab=clk_chin}
N -1705 20 -1745 20 {}
C {devices/lab_wire.sym} -1745 20 0 0 {name=l67 lab=clk_chin_not}
N -1425 -20 -1385 -20 {}
C {devices/lab_wire.sym} -1385 -20 0 1 {name=l68 lab=inch_n}
N -1425 20 -1385 20 {}
C {devices/lab_wire.sym} -1385 20 0 1 {name=l69 lab=vinn}
N -1565 -80 -1565 -120 {}
C {devices/lab_wire.sym} -1565 -120 0 1 {name=l70 lab=vdd}
N -1565 80 -1565 120 {}
C {devices/lab_wire.sym} -1565 120 2 0 {name=l71 lab=vss}
N -1205 -20 -1245 -20 {}
C {devices/lab_wire.sym} -1245 -20 0 0 {name=l72 lab=clk_chin}
N -1205 20 -1245 20 {}
C {devices/lab_wire.sym} -1245 20 0 0 {name=l73 lab=clk_chin_not}
N -925 -20 -885 -20 {}
C {devices/lab_wire.sym} -885 -20 0 1 {name=l74 lab=inch_p}
N -925 20 -885 20 {}
C {devices/lab_wire.sym} -885 20 0 1 {name=l75 lab=vinp}
N -1065 -80 -1065 -120 {}
C {devices/lab_wire.sym} -1065 -120 0 1 {name=l76 lab=vdd}
N -1065 80 -1065 120 {}
C {devices/lab_wire.sym} -1065 120 2 0 {name=l77 lab=vss}
N -705 -20 -745 -20 {}
C {devices/lab_wire.sym} -745 -20 0 0 {name=l78 lab=clk_chpf}
N -705 20 -745 20 {}
C {devices/lab_wire.sym} -745 20 0 0 {name=l79 lab=clk_chpf_not}
N -425 -20 -385 -20 {}
C {devices/lab_wire.sym} -385 -20 0 1 {name=l80 lab=pfch_p}
N -425 20 -385 20 {}
C {devices/lab_wire.sym} -385 20 0 1 {name=l81 lab=voutp}
N -565 -80 -565 -120 {}
C {devices/lab_wire.sym} -565 -120 0 1 {name=l82 lab=vdd}
N -565 80 -565 120 {}
C {devices/lab_wire.sym} -565 120 2 0 {name=l83 lab=vss}
N -205 -20 -245 -20 {}
C {devices/lab_wire.sym} -245 -20 0 0 {name=l84 lab=clk_chfb_not}
N -205 20 -245 20 {}
C {devices/lab_wire.sym} -245 20 0 0 {name=l85 lab=clk_chpf}
N 15 -40 55 -40 {}
C {devices/lab_wire.sym} 55 -40 0 1 {name=l86 lab=fbch_n}
N 15 0 55 0 {}
C {devices/lab_wire.sym} 55 0 0 1 {name=l87 lab=pfch_p}
N 15 40 55 40 {}
C {devices/lab_wire.sym} 55 40 0 1 {name=l88 lab=voutp}
N -95 100 -95 140 {}
C {devices/lab_wire.sym} -95 140 2 0 {name=l89 lab=vss}
N 235 -20 195 -20 {}
C {devices/lab_wire.sym} 195 -20 0 0 {name=l90 lab=clk_chpf}
N 235 20 195 20 {}
C {devices/lab_wire.sym} 195 20 0 0 {name=l91 lab=clk_chpf_not}
N 455 -40 495 -40 {}
C {devices/lab_wire.sym} 495 -40 0 1 {name=l92 lab=pfch_n}
N 455 0 495 0 {}
C {devices/lab_wire.sym} 495 0 0 1 {name=l93 lab=pfch_p}
N 455 40 495 40 {}
C {devices/lab_wire.sym} 495 40 0 1 {name=l94 lab=voutp}
N 345 100 345 140 {}
C {devices/lab_wire.sym} 345 140 2 0 {name=l95 lab=vss}
N 675 -20 635 -20 {}
C {devices/lab_wire.sym} 635 -20 0 0 {name=l96 lab=clk_chpf}
N 675 20 635 20 {}
C {devices/lab_wire.sym} 635 20 0 0 {name=l97 lab=clk_chpf_not}
N 955 -20 995 -20 {}
C {devices/lab_wire.sym} 995 -20 0 1 {name=l98 lab=pfch_n}
N 955 20 995 20 {}
C {devices/lab_wire.sym} 995 20 0 1 {name=l99 lab=voutn}
N 815 -80 815 -120 {}
C {devices/lab_wire.sym} 815 -120 0 1 {name=l100 lab=vdd}
N 815 80 815 120 {}
C {devices/lab_wire.sym} 815 120 2 0 {name=l101 lab=vss}
N 1175 -20 1135 -20 {}
C {devices/lab_wire.sym} 1135 -20 0 0 {name=l102 lab=clk_chfb_not}
N 1175 20 1135 20 {}
C {devices/lab_wire.sym} 1135 20 0 0 {name=l103 lab=clk_chpf}
N 1395 -40 1435 -40 {}
C {devices/lab_wire.sym} 1435 -40 0 1 {name=l104 lab=fbch_p}
N 1395 0 1435 0 {}
C {devices/lab_wire.sym} 1435 0 0 1 {name=l105 lab=pfch_n}
N 1395 40 1435 40 {}
C {devices/lab_wire.sym} 1435 40 0 1 {name=l106 lab=voutn}
N 1285 100 1285 140 {}
C {devices/lab_wire.sym} 1285 140 2 0 {name=l107 lab=vss}
N 1615 -20 1575 -20 {}
C {devices/lab_wire.sym} 1575 -20 0 0 {name=l108 lab=clk_chpf}
N 1615 20 1575 20 {}
C {devices/lab_wire.sym} 1575 20 0 0 {name=l109 lab=clk_chpf_not}
N 1835 -40 1875 -40 {}
C {devices/lab_wire.sym} 1875 -40 0 1 {name=l110 lab=pfch_n}
N 1835 0 1875 0 {}
C {devices/lab_wire.sym} 1875 0 0 1 {name=l111 lab=pfch_p}
N 1835 40 1875 40 {}
C {devices/lab_wire.sym} 1875 40 0 1 {name=l112 lab=voutn}
N 1725 100 1725 140 {}
C {devices/lab_wire.sym} 1725 140 2 0 {name=l113 lab=vss}
N 2055 -20 2015 -20 {}
C {devices/lab_wire.sym} 2015 -20 0 0 {name=l114 lab=clk_chout}
N 2055 20 2015 20 {}
C {devices/lab_wire.sym} 2015 20 0 0 {name=l115 lab=clk_chout_not}
N 2335 -20 2375 -20 {}
C {devices/lab_wire.sym} 2375 -20 0 1 {name=l116 lab=g2_p}
N 2335 20 2375 20 {}
C {devices/lab_wire.sym} 2375 20 0 1 {name=l117 lab=out1_n}
N 2195 -80 2195 -120 {}
C {devices/lab_wire.sym} 2195 -120 0 1 {name=l118 lab=vdd}
N 2195 80 2195 120 {}
C {devices/lab_wire.sym} 2195 120 2 0 {name=l119 lab=vss}
N 2555 -20 2515 -20 {}
C {devices/lab_wire.sym} 2515 -20 0 0 {name=l120 lab=clk_chout}
N 2555 20 2515 20 {}
C {devices/lab_wire.sym} 2515 20 0 0 {name=l121 lab=clk_chout_not}
N 2845 -20 2885 -20 {}
C {devices/lab_wire.sym} 2885 -20 0 1 {name=l122 lab=g2_n}
N 2845 20 2885 20 {}
C {devices/lab_wire.sym} 2885 20 0 1 {name=l123 lab=out1_p}
N 2700 -80 2700 -120 {}
C {devices/lab_wire.sym} 2700 -120 0 1 {name=l124 lab=vdd}
N 2700 80 2700 120 {}
C {devices/lab_wire.sym} 2700 120 2 0 {name=l125 lab=vss}
N 3065 -20 3025 -20 {}
C {devices/lab_wire.sym} 3025 -20 0 0 {name=l126 lab=clk_chin}
N 3065 20 3025 20 {}
C {devices/lab_wire.sym} 3025 20 0 0 {name=l127 lab=clk_chin_not}
N 3355 -20 3395 -20 {}
C {devices/lab_wire.sym} 3395 -20 0 1 {name=l128 lab=inch_p}
N 3355 20 3395 20 {}
C {devices/lab_wire.sym} 3395 20 0 1 {name=l129 lab=vinn}
N 3210 -80 3210 -120 {}
C {devices/lab_wire.sym} 3210 -120 0 1 {name=l130 lab=vdd}
N 3210 80 3210 120 {}
C {devices/lab_wire.sym} 3210 120 2 0 {name=l131 lab=vss}
N 3575 -20 3535 -20 {}
C {devices/lab_wire.sym} 3535 -20 0 0 {name=l132 lab=clk_chin}
N 3575 20 3535 20 {}
C {devices/lab_wire.sym} 3535 20 0 0 {name=l133 lab=clk_chin_not}
N 3865 -20 3905 -20 {}
C {devices/lab_wire.sym} 3905 -20 0 1 {name=l134 lab=inch_n}
N 3865 20 3905 20 {}
C {devices/lab_wire.sym} 3905 20 0 1 {name=l135 lab=vinp}
N 3720 -80 3720 -120 {}
C {devices/lab_wire.sym} 3720 -120 0 1 {name=l136 lab=vdd}
N 3720 80 3720 120 {}
C {devices/lab_wire.sym} 3720 120 2 0 {name=l137 lab=vss}
N 4085 -20 4045 -20 {}
C {devices/lab_wire.sym} 4045 -20 0 0 {name=l138 lab=clk_chfb}
N 4085 20 4045 20 {}
C {devices/lab_wire.sym} 4045 20 0 0 {name=l139 lab=clk_chfb_not}
N 4375 -20 4415 -20 {}
C {devices/lab_wire.sym} 4415 -20 0 1 {name=l140 lab=fbch_p}
N 4375 20 4415 20 {}
C {devices/lab_wire.sym} 4415 20 0 1 {name=l141 lab=voutn}
N 4230 -80 4230 -120 {}
C {devices/lab_wire.sym} 4230 -120 0 1 {name=l142 lab=vdd}
N 4230 80 4230 120 {}
C {devices/lab_wire.sym} 4230 120 2 0 {name=l143 lab=vss}
N 4595 -20 4555 -20 {}
C {devices/lab_wire.sym} 4555 -20 0 0 {name=l144 lab=clk_chfb_not}
N 4595 20 4555 20 {}
C {devices/lab_wire.sym} 4555 20 0 0 {name=l145 lab=clk_chpf_not}
N 4815 -40 4855 -40 {}
C {devices/lab_wire.sym} 4855 -40 0 1 {name=l146 lab=fbch_p}
N 4815 0 4855 0 {}
C {devices/lab_wire.sym} 4855 0 0 1 {name=l147 lab=pfch_p}
N 4815 40 4855 40 {}
C {devices/lab_wire.sym} 4855 40 0 1 {name=l148 lab=voutn}
N 4705 100 4705 140 {}
C {devices/lab_wire.sym} 4705 140 2 0 {name=l149 lab=vss}
N 5035 -20 4995 -20 {}
C {devices/lab_wire.sym} 4995 -20 0 0 {name=l150 lab=clk_chfb}
N 5035 20 4995 20 {}
C {devices/lab_wire.sym} 4995 20 0 0 {name=l151 lab=clk_chfb_not}
N 5325 -20 5365 -20 {}
C {devices/lab_wire.sym} 5365 -20 0 1 {name=l152 lab=fbch_n}
N 5325 20 5365 20 {}
C {devices/lab_wire.sym} 5365 20 0 1 {name=l153 lab=voutp}
N 5180 -80 5180 -120 {}
C {devices/lab_wire.sym} 5180 -120 0 1 {name=l154 lab=vdd}
N 5180 80 5180 120 {}
C {devices/lab_wire.sym} 5180 120 2 0 {name=l155 lab=vss}
N 5545 -20 5505 -20 {}
C {devices/lab_wire.sym} 5505 -20 0 0 {name=l156 lab=clk_chfb_not}
N 5545 20 5505 20 {}
C {devices/lab_wire.sym} 5505 20 0 0 {name=l157 lab=clk_chpf_not}
N 5765 -40 5805 -40 {}
C {devices/lab_wire.sym} 5805 -40 0 1 {name=l158 lab=fbch_n}
N 5765 0 5805 0 {}
C {devices/lab_wire.sym} 5805 0 0 1 {name=l159 lab=pfch_n}
N 5765 40 5805 40 {}
C {devices/lab_wire.sym} 5805 40 0 1 {name=l160 lab=voutp}
N 5655 100 5655 140 {}
C {devices/lab_wire.sym} 5655 140 2 0 {name=l161 lab=vss}
N 5985 -20 5945 -20 {}
C {devices/lab_wire.sym} 5945 -20 0 0 {name=l162 lab=clk_chpf}
N 5985 20 5945 20 {}
C {devices/lab_wire.sym} 5945 20 0 0 {name=l163 lab=clk_chpf_not}
N 6275 -20 6315 -20 {}
C {devices/lab_wire.sym} 6315 -20 0 1 {name=l164 lab=pfch_p}
N 6275 20 6315 20 {}
C {devices/lab_wire.sym} 6315 20 0 1 {name=l165 lab=voutn}
N 6130 -80 6130 -120 {}
C {devices/lab_wire.sym} 6130 -120 0 1 {name=l166 lab=vdd}
N 6130 80 6130 120 {}
C {devices/lab_wire.sym} 6130 120 2 0 {name=l167 lab=vss}
N 6495 -20 6455 -20 {}
C {devices/lab_wire.sym} 6455 -20 0 0 {name=l168 lab=clk_chpf}
N 6495 20 6455 20 {}
C {devices/lab_wire.sym} 6455 20 0 0 {name=l169 lab=clk_chpf_not}
N 6785 -20 6825 -20 {}
C {devices/lab_wire.sym} 6825 -20 0 1 {name=l170 lab=pfch_n}
N 6785 20 6825 20 {}
C {devices/lab_wire.sym} 6825 20 0 1 {name=l171 lab=voutp}
N 6640 -80 6640 -120 {}
C {devices/lab_wire.sym} 6640 -120 0 1 {name=l172 lab=vdd}
N 6640 80 6640 120 {}
C {devices/lab_wire.sym} 6640 120 2 0 {name=l173 lab=vss}
N -1650 310 -1650 270 {}
C {devices/lab_wire.sym} -1650 270 0 1 {name=l174 lab=fbch_p}
N -1650 370 -1650 410 {}
C {devices/lab_wire.sym} -1650 410 2 0 {name=l175 lab=vsum_n}
N -1430 310 -1430 270 {}
C {devices/lab_wire.sym} -1430 270 0 1 {name=l176 lab=fbch_n}
N -1430 370 -1430 410 {}
C {devices/lab_wire.sym} -1430 410 2 0 {name=l177 lab=vsum_p}
N -1210 310 -1210 270 {}
C {devices/lab_wire.sym} -1210 270 0 1 {name=l178 lab=vsum_n}
N -1210 370 -1210 410 {}
C {devices/lab_wire.sym} -1210 410 2 0 {name=l179 lab=inch_n}
N -990 310 -990 270 {}
C {devices/lab_wire.sym} -990 270 0 1 {name=l180 lab=vsum_p}
N -990 370 -990 410 {}
C {devices/lab_wire.sym} -990 410 2 0 {name=l181 lab=inch_p}
N -770 310 -770 270 {}
C {devices/lab_wire.sym} -770 270 0 1 {name=l182 lab=g2_p}
N -770 370 -770 410 {}
C {devices/lab_wire.sym} -770 410 2 0 {name=l183 lab=voutp}
N -550 310 -550 270 {}
C {devices/lab_wire.sym} -550 270 0 1 {name=l184 lab=g2_n}
N -550 370 -550 410 {}
C {devices/lab_wire.sym} -550 410 2 0 {name=l185 lab=voutn}
N -330 310 -330 270 {}
C {devices/lab_wire.sym} -330 270 0 1 {name=l186 lab=pfch_p}
N -330 370 -330 410 {}
C {devices/lab_wire.sym} -330 410 2 0 {name=l187 lab=inch_p}
N -110 310 -110 270 {}
C {devices/lab_wire.sym} -110 270 0 1 {name=l188 lab=pfch_n}
N -110 370 -110 410 {}
C {devices/lab_wire.sym} -110 410 2 0 {name=l189 lab=inch_n}
N 110 310 110 270 {}
C {devices/lab_wire.sym} 110 270 0 1 {name=l190 lab=vsum_n}
N 110 370 110 410 {}
C {devices/lab_wire.sym} 110 410 2 0 {name=l191 lab=vref}
N 330 310 330 270 {}
C {devices/lab_wire.sym} 330 270 0 1 {name=l192 lab=vsum_p}
N 330 370 330 410 {}
C {devices/lab_wire.sym} 330 410 2 0 {name=l193 lab=vref}
N -6865 310 -6865 270 {}
C {devices/lab_wire.sym} -6865 270 0 1 {name=l194 lab=vb1}
N -6865 370 -6865 410 {}
C {devices/lab_wire.sym} -6865 410 2 0 {name=l195 lab=vss}
N -6865 90 -6865 50 {}
C {devices/lab_wire.sym} -6865 50 0 1 {name=l196 lab=vb2}
N -6865 150 -6865 190 {}
C {devices/lab_wire.sym} -6865 190 2 0 {name=l197 lab=vss}
N -6865 -130 -6865 -170 {}
C {devices/lab_wire.sym} -6865 -170 0 1 {name=l198 lab=vb3}
N -6865 -70 -6865 -30 {}
C {devices/lab_wire.sym} -6865 -30 2 0 {name=l199 lab=vss}
N -6865 -350 -6865 -390 {}
C {devices/lab_wire.sym} -6865 -390 0 1 {name=l200 lab=vb4}
N -6865 -290 -6865 -250 {}
C {devices/lab_wire.sym} -6865 -250 2 0 {name=l201 lab=vss}
N -640 -310 -640 -270 {}
C {devices/lab_wire.sym} -640 -270 2 0 {name=l202 lab=tail}
N -680 -340 -720 -340 {}
C {devices/lab_wire.sym} -720 -340 0 0 {name=l203 lab=vb4}
N -640 -370 -640 -410 {}
C {devices/lab_wire.sym} -640 -410 0 1 {name=l204 lab=vdd}
N -640 -340 -600 -340 {}
C {devices/lab_wire.sym} -600 -340 0 1 {name=l205 lab=vdd}
N -420 -310 -420 -270 {}
C {devices/lab_wire.sym} -420 -270 2 0 {name=l206 lab=out1_n}
N -460 -340 -500 -340 {}
C {devices/lab_wire.sym} -500 -340 0 0 {name=l207 lab=vb3}
N -420 -370 -420 -410 {}
C {devices/lab_wire.sym} -420 -410 0 1 {name=l208 lab=casc_src_n}
N -420 -340 -380 -340 {}
C {devices/lab_wire.sym} -380 -340 0 1 {name=l209 lab=vdd}
N -200 -310 -200 -270 {}
C {devices/lab_wire.sym} -200 -270 2 0 {name=l210 lab=out1_p}
N -240 -340 -280 -340 {}
C {devices/lab_wire.sym} -280 -340 0 0 {name=l211 lab=vb3}
N -200 -370 -200 -410 {}
C {devices/lab_wire.sym} -200 -410 0 1 {name=l212 lab=casc_src_p}
N -200 -340 -160 -340 {}
C {devices/lab_wire.sym} -160 -340 0 1 {name=l213 lab=vdd}
N 570 310 570 270 {}
C {devices/lab_wire.sym} 570 270 0 1 {name=l214 lab=out1_p}
N 530 340 490 340 {}
C {devices/lab_wire.sym} 490 340 0 0 {name=l215 lab=vb2}
N 570 370 570 410 {}
C {devices/lab_wire.sym} 570 410 2 0 {name=l216 lab=fold_p}
N 570 340 610 340 {}
C {devices/lab_wire.sym} 610 340 0 1 {name=l217 lab=vss}
N 790 310 790 270 {}
C {devices/lab_wire.sym} 790 270 0 1 {name=l218 lab=out1_n}
N 750 340 710 340 {}
C {devices/lab_wire.sym} 710 340 0 0 {name=l219 lab=vb2}
N 790 370 790 410 {}
C {devices/lab_wire.sym} 790 410 2 0 {name=l220 lab=fold_n}
N 790 340 830 340 {}
C {devices/lab_wire.sym} 830 340 0 1 {name=l221 lab=vss}
N 1010 310 1010 270 {}
C {devices/lab_wire.sym} 1010 270 0 1 {name=l222 lab=voutp}
N 970 340 930 340 {}
C {devices/lab_wire.sym} 930 340 0 0 {name=l223 lab=g2_p}
N 1010 370 1010 410 {}
C {devices/lab_wire.sym} 1010 410 2 0 {name=l224 lab=vss}
N 1010 340 1050 340 {}
C {devices/lab_wire.sym} 1050 340 0 1 {name=l225 lab=vss}
N 1230 310 1230 270 {}
C {devices/lab_wire.sym} 1230 270 0 1 {name=l226 lab=voutn}
N 1190 340 1150 340 {}
C {devices/lab_wire.sym} 1150 340 0 0 {name=l227 lab=g2_n}
N 1230 370 1230 410 {}
C {devices/lab_wire.sym} 1230 410 2 0 {name=l228 lab=vss}
N 1230 340 1270 340 {}
C {devices/lab_wire.sym} 1270 340 0 1 {name=l229 lab=vss}
N 1450 310 1450 270 {}
C {devices/lab_wire.sym} 1450 270 0 1 {name=l230 lab=fold_p}
N 1410 340 1370 340 {}
C {devices/lab_wire.sym} 1370 340 0 0 {name=l231 lab=vb1}
N 1450 370 1450 410 {}
C {devices/lab_wire.sym} 1450 410 2 0 {name=l232 lab=vss}
N 1450 340 1490 340 {}
C {devices/lab_wire.sym} 1490 340 0 1 {name=l233 lab=vss}
N 1670 310 1670 270 {}
C {devices/lab_wire.sym} 1670 270 0 1 {name=l234 lab=fold_n}
N 1630 340 1590 340 {}
C {devices/lab_wire.sym} 1590 340 0 0 {name=l235 lab=vb1}
N 1670 370 1670 410 {}
C {devices/lab_wire.sym} 1670 410 2 0 {name=l236 lab=vss}
N 1670 340 1710 340 {}
C {devices/lab_wire.sym} 1710 340 0 1 {name=l237 lab=vss}
N 20 -310 20 -270 {}
C {devices/lab_wire.sym} 20 -270 2 0 {name=l238 lab=casc_src_n}
N -20 -340 -60 -340 {}
C {devices/lab_wire.sym} -60 -340 0 0 {name=l239 lab=vb4}
N 20 -370 20 -410 {}
C {devices/lab_wire.sym} 20 -410 0 1 {name=l240 lab=vdd}
N 20 -340 60 -340 {}
C {devices/lab_wire.sym} 60 -340 0 1 {name=l241 lab=vdd}
N 240 -310 240 -270 {}
C {devices/lab_wire.sym} 240 -270 2 0 {name=l242 lab=casc_src_p}
N 200 -340 160 -340 {}
C {devices/lab_wire.sym} 160 -340 0 0 {name=l243 lab=vb4}
N 240 -370 240 -410 {}
C {devices/lab_wire.sym} 240 -410 0 1 {name=l244 lab=vdd}
N 240 -340 280 -340 {}
C {devices/lab_wire.sym} 280 -340 0 1 {name=l245 lab=vdd}
N 460 -310 460 -270 {}
C {devices/lab_wire.sym} 460 -270 2 0 {name=l246 lab=voutp}
N 420 -340 380 -340 {}
C {devices/lab_wire.sym} 380 -340 0 0 {name=l247 lab=vb4}
N 460 -370 460 -410 {}
C {devices/lab_wire.sym} 460 -410 0 1 {name=l248 lab=vdd}
N 460 -340 500 -340 {}
C {devices/lab_wire.sym} 500 -340 0 1 {name=l249 lab=vdd}
N 680 -310 680 -270 {}
C {devices/lab_wire.sym} 680 -270 2 0 {name=l250 lab=voutn}
N 640 -340 600 -340 {}
C {devices/lab_wire.sym} 600 -340 0 0 {name=l251 lab=vb4}
N 680 -370 680 -410 {}
C {devices/lab_wire.sym} 680 -410 0 1 {name=l252 lab=vdd}
N 680 -340 720 -340 {}
C {devices/lab_wire.sym} 720 -340 0 1 {name=l253 lab=vdd}
