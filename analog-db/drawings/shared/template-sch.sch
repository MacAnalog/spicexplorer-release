v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 80 -340 520 -340 {
lab=VDD}
N 80 -120 520 -120 {
lab=VSS}
C {devices/title.sym} 170 -40 0 0 {name=l5 author="Copyright 2026 MacAnalog Research Group"}
C {iopin.sym} 80 -340 0 1 {name=p4 lab=VDD}
C {iopin.sym} 80 -120 0 1 {name=p1 lab=VSS}
