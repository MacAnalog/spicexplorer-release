v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_016_song_dacfc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -430 390 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 445 780 0 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -430 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 80 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -430 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -90 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1730 520 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 445 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -430 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -90 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 80 780 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -90 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 805 780 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 80 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -800 520 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 1275 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1730 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 80 260 0 0 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} 1275 260 0 0 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} 1500 0 0 0 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 445 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 1730 260 0 0 {name=M60 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm60_w l=x_dut_xm60_l m=x_dut_xm60_m}
C {devices/sg13_lv_pmos_np.sym} 445 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 2070 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_pmos_np.sym} 985 260 0 0 {name=M63 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 1325 780 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_nmos_np.sym} 985 780 0 0 {name=M65 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 985 0 0 0 {name=M68 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_pmos_np.sym} 2070 0 0 0 {name=M69 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 2300 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 985 520 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_nmos_np.sym} 1325 520 0 0 {name=M71 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm71_w l=x_dut_xm71_l m=x_dut_xm71_m}
C {devices/sg13_lv_pmos_np.sym} 1500 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 805 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 690 -1915 750 {}
N -1915 810 -1915 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 920 {}
N -1540 260 -1540 460 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 920 {}
N -830 190 -830 260 {}
N -780 460 -780 490 {}
N -780 550 -780 920 {}
N -720 520 -720 614 {}
N -510 0 -510 94 {}
N -510 260 -510 354 {}
N -510 520 -510 614 {}
N -450 -140 -450 -30 {}
N -450 30 -450 90 {}
N -450 170 -450 230 {}
N -450 290 -450 350 {}
N -450 430 -450 490 {}
N -450 550 -450 920 {}
N -410 140 -410 260 {}
N -400 390 -400 450 {}
N -170 0 -170 94 {}
N -170 320 -170 490 {}
N -170 520 -170 614 {}
N -110 -140 -110 -30 {}
N -110 30 -110 230 {}
N -110 290 -110 350 {}
N -110 550 -110 920 {}
N -70 0 -70 70 {}
N -70 520 -70 580 {}
N -40 140 -40 260 {}
N -20 60 -20 320 {}
N 30 520 30 840 {}
N 60 450 60 520 {}
N 100 -140 100 -30 {}
N 100 30 100 90 {}
N 100 170 100 230 {}
N 100 290 100 320 {}
N 100 430 100 490 {}
N 100 550 100 610 {}
N 100 690 100 750 {}
N 100 810 100 920 {}
N 160 0 160 94 {}
N 160 260 160 354 {}
N 160 520 160 614 {}
N 160 780 160 874 {}
N 365 0 365 94 {}
N 365 260 365 354 {}
N 365 520 365 614 {}
N 425 -140 425 -30 {}
N 425 30 425 90 {}
N 425 170 425 230 {}
N 425 290 425 350 {}
N 425 430 425 490 {}
N 425 550 425 580 {}
N 445 690 445 750 {}
N 445 810 445 920 {}
N 725 320 725 750 {}
N 725 780 725 874 {}
N 785 170 785 230 {}
N 785 290 785 320 {}
N 785 320 785 350 {}
N 785 810 785 920 {}
N 845 320 845 580 {}
N 855 780 855 840 {}
N 875 0 875 320 {}
N 935 460 935 520 {}
N 935 720 935 780 {}
N 945 60 945 230 {}
N 945 320 945 490 {}
N 945 580 945 750 {}
N 965 200 965 260 {}
N 1005 -140 1005 -30 {}
N 1005 30 1005 90 {}
N 1005 290 1005 320 {}
N 1005 550 1005 610 {}
N 1005 810 1005 920 {}
N 1065 0 1065 94 {}
N 1065 260 1065 354 {}
N 1065 520 1065 614 {}
N 1065 780 1065 874 {}
N 1275 460 1275 520 {}
N 1275 720 1275 780 {}
N 1295 -140 1295 -30 {}
N 1295 30 1295 90 {}
N 1295 170 1295 230 {}
N 1295 290 1295 320 {}
N 1345 430 1345 490 {}
N 1345 550 1345 610 {}
N 1345 690 1345 750 {}
N 1345 810 1345 920 {}
N 1355 0 1355 94 {}
N 1355 260 1355 354 {}
N 1405 520 1405 614 {}
N 1405 780 1405 874 {}
N 1520 -140 1520 -30 {}
N 1520 30 1520 90 {}
N 1520 170 1520 230 {}
N 1520 290 1520 350 {}
N 1580 0 1580 94 {}
N 1580 260 1580 354 {}
N 1750 -140 1750 -30 {}
N 1750 30 1750 230 {}
N 1750 290 1750 350 {}
N 1750 460 1750 490 {}
N 1750 550 1750 610 {}
N 1810 0 1810 94 {}
N 1810 260 1810 354 {}
N 1810 520 1810 614 {}
N 2090 -140 2090 -30 {}
N 2090 30 2090 230 {}
N 2090 290 2090 350 {}
N 2150 0 2150 94 {}
N 2150 260 2150 354 {}
N 2320 -140 2320 -30 {}
N 2320 30 2320 90 {}
N 2380 0 2380 94 {}
N 2520 60 2520 320 {}
N -2030 -140 2775 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -510 0 -450 0 {}
N -410 0 -350 0 {}
N -170 0 -110 0 {}
N 0 0 60 0 {}
N 100 0 160 0 {}
N 365 0 425 0 {}
N 465 0 525 0 {}
N 875 0 965 0 {}
N 1005 0 1065 0 {}
N 1195 0 1255 0 {}
N 1295 0 1355 0 {}
N 1420 0 1480 0 {}
N 1520 0 1580 0 {}
N 1650 0 1710 0 {}
N 1750 0 1810 0 {}
N 1990 0 2050 0 {}
N 2090 0 2150 0 {}
N 2220 0 2280 0 {}
N 2320 0 2380 0 {}
N -20 60 100 60 {}
N 945 60 1005 60 {}
N 2320 60 2520 60 {}
N -1210 70 -1170 70 {}
N -110 70 -70 70 {}
N -410 140 -40 140 {}
N -870 190 -830 190 {}
N 945 230 1005 230 {}
N -1610 260 -1550 260 {}
N -1540 260 -1450 260 {}
N -930 260 -870 260 {}
N -510 260 -450 260 {}
N -410 260 -350 260 {}
N -70 260 -40 260 {}
N 0 260 60 260 {}
N 100 260 160 260 {}
N 365 260 425 260 {}
N 465 260 525 260 {}
N 825 260 855 260 {}
N 935 260 965 260 {}
N 1005 260 1065 260 {}
N 1195 260 1255 260 {}
N 1295 260 1355 260 {}
N 1420 260 1480 260 {}
N 1520 260 1580 260 {}
N 1650 260 1710 260 {}
N 1750 260 1810 260 {}
N 1990 260 2050 260 {}
N 2090 260 2150 260 {}
N -170 320 -110 320 {}
N -20 320 100 320 {}
N 725 320 845 320 {}
N 875 320 1005 320 {}
N 1295 320 2520 320 {}
N -520 390 -460 390 {}
N -400 390 -370 390 {}
N 60 450 100 450 {}
N -1540 460 -780 460 {}
N 935 460 1275 460 {}
N 1345 460 1750 460 {}
N -170 490 -110 490 {}
N 945 490 1005 490 {}
N -880 520 -820 520 {}
N -780 520 -720 520 {}
N -510 520 -450 520 {}
N -410 520 -350 520 {}
N -170 520 -110 520 {}
N -70 520 30 520 {}
N 100 520 160 520 {}
N 365 520 425 520 {}
N 465 520 965 520 {}
N 1005 520 1065 520 {}
N 1275 520 1305 520 {}
N 1345 520 1405 520 {}
N 1650 520 1710 520 {}
N 1750 520 1810 520 {}
N 425 580 845 580 {}
N 945 580 1005 580 {}
N 935 720 1275 720 {}
N 725 750 785 750 {}
N 945 750 1005 750 {}
N 30 780 60 780 {}
N 100 780 160 780 {}
N 725 780 785 780 {}
N 825 780 965 780 {}
N 1005 780 1065 780 {}
N 1275 780 1305 780 {}
N 1345 780 1405 780 {}
N 30 840 855 840 {}
N -2030 920 2775 920 {}
C {devices/lab_wire.sym} -70 60 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 525 260 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 965 200 0 1 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} 1650 260 0 0 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 1990 260 0 0 {name=l4 lab=DM_1}
C {devices/lab_wire.sym} 100 690 0 1 {name=l5 lab=DM_2}
C {devices/lab_wire.sym} 1520 350 2 0 {name=l6 lab=DM_2}
C {devices/lab_wire.sym} 1750 610 2 0 {name=l7 lab=DM_2}
C {devices/lab_wire.sym} -870 90 2 0 {name=l8 lab=VB3}
C {devices/lab_wire.sym} -870 170 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} -350 260 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} 525 520 0 1 {name=l11 lab=VB3}
C {devices/lab_wire.sym} 1650 520 0 0 {name=l12 lab=VB3}
C {devices/lab_wire.sym} -450 90 2 0 {name=l13 lab=VB4}
C {devices/lab_wire.sym} -450 170 0 1 {name=l14 lab=VB4}
C {devices/lab_wire.sym} -350 520 0 1 {name=l15 lab=VB4}
C {devices/lab_wire.sym} -70 580 2 0 {name=l16 lab=VB4}
C {devices/lab_wire.sym} 0 260 0 0 {name=l17 lab=VINN}
C {devices/lab_wire.sym} 1420 260 0 0 {name=l18 lab=VINN}
C {devices/lab_wire.sym} 825 260 0 0 {name=l19 lab=VINP}
C {devices/lab_wire.sym} 1195 260 0 0 {name=l20 lab=VINP}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l21 lab=VOUT}
C {devices/lab_wire.sym} -400 450 2 0 {name=l22 lab=VOUT}
C {devices/lab_wire.sym} 525 0 0 1 {name=l23 lab=VOUTN}
C {devices/lab_wire.sym} 1345 430 0 1 {name=l24 lab=VOUTN}
C {devices/lab_wire.sym} 1650 0 0 0 {name=l25 lab=VOUTN}
C {devices/lab_wire.sym} 1750 350 2 0 {name=l26 lab=VOUTN}
C {devices/lab_wire.sym} 2090 350 2 0 {name=l27 lab=VOUTN}
C {devices/lab_wire.sym} 2220 0 0 0 {name=l28 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l29 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l30 lab=net013}
C {devices/lab_wire.sym} -350 0 0 1 {name=l31 lab=net013}
C {devices/lab_wire.sym} 1195 0 0 0 {name=l32 lab=net013}
C {devices/lab_wire.sym} 1420 0 0 0 {name=l33 lab=net013}
C {devices/lab_wire.sym} -880 520 0 0 {name=l34 lab=net043}
C {devices/lab_wire.sym} 100 430 0 1 {name=l35 lab=net043}
C {devices/lab_wire.sym} 100 90 2 0 {name=l36 lab=net043}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l37 lab=net049}
C {devices/lab_wire.sym} 2320 90 2 0 {name=l38 lab=net049}
C {devices/lab_wire.sym} 425 90 2 0 {name=l39 lab=net050}
C {devices/lab_wire.sym} 425 170 0 1 {name=l40 lab=net050}
C {devices/lab_wire.sym} 785 350 2 0 {name=l41 lab=net063}
C {devices/lab_wire.sym} 100 170 0 1 {name=l42 lab=net1}
C {devices/lab_wire.sym} 1295 170 0 1 {name=l43 lab=net1}
C {devices/lab_wire.sym} 1520 90 2 0 {name=l44 lab=net1}
C {devices/lab_wire.sym} 1005 90 2 0 {name=l45 lab=net2}
C {devices/lab_wire.sym} 2090 90 2 0 {name=l46 lab=net3}
C {devices/lab_wire.sym} 785 170 0 1 {name=l47 lab=net31}
C {devices/lab_wire.sym} 1295 90 2 0 {name=l48 lab=net31}
C {devices/lab_wire.sym} 1520 170 0 1 {name=l49 lab=net31}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l50 lab=net4}
C {devices/lab_wire.sym} 0 0 0 0 {name=l51 lab=net4}
C {devices/lab_wire.sym} 425 350 2 0 {name=l52 lab=net4}
C {devices/lab_wire.sym} 425 430 0 1 {name=l53 lab=net4}
C {devices/lab_wire.sym} 445 690 0 1 {name=l54 lab=net4}
C {devices/lab_wire.sym} 1750 90 2 0 {name=l55 lab=net5}
C {devices/lab_wire.sym} -450 350 2 0 {name=l56 lab=net54}
C {devices/lab_wire.sym} -450 430 0 1 {name=l57 lab=net54}
C {devices/lab_wire.sym} -110 350 2 0 {name=l58 lab=net56}
C {devices/lab_wire.sym} 1005 610 2 0 {name=l59 lab=net69}
C {devices/lab_wire.sym} -520 390 0 0 {name=l60 lab=net70}
C {devices/lab_wire.sym} 905 0 0 0 {name=l61 lab=net70}
C {devices/lab_wire.sym} 1990 0 0 0 {name=l62 lab=net70}
C {devices/lab_wire.sym} 1345 610 2 0 {name=l63 lab=net85}
C {devices/lab_wire.sym} 1345 690 0 1 {name=l64 lab=net85}
C {devices/lab_wire.sym} 160 354 2 0 {name=l65 lab=net1}
C {devices/lab_wire.sym} 1355 354 2 0 {name=l66 lab=net1}
C {devices/lab_wire.sym} 1580 354 2 0 {name=l67 lab=net31}
C {devices/lab_wire.sym} 785 260 0 0 {name=l68 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l69 lab=vdd}
C {devices/lab_wire.sym} -510 94 2 0 {name=l70 lab=vdd}
C {devices/lab_wire.sym} 160 94 2 0 {name=l71 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l72 lab=vdd}
C {devices/lab_wire.sym} -170 94 2 0 {name=l73 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l74 lab=vdd}
C {devices/lab_wire.sym} 1355 94 2 0 {name=l75 lab=vdd}
C {devices/lab_wire.sym} 1810 94 2 0 {name=l76 lab=vdd}
C {devices/lab_wire.sym} 1580 94 2 0 {name=l77 lab=vdd}
C {devices/lab_wire.sym} 365 94 2 0 {name=l78 lab=vdd}
C {devices/lab_wire.sym} 1810 354 2 0 {name=l79 lab=vdd}
C {devices/lab_wire.sym} 365 354 2 0 {name=l80 lab=vdd}
C {devices/lab_wire.sym} 2150 354 2 0 {name=l81 lab=vdd}
C {devices/lab_wire.sym} 1065 354 2 0 {name=l82 lab=vdd}
C {devices/lab_wire.sym} 1065 94 2 0 {name=l83 lab=vdd}
C {devices/lab_wire.sym} 2150 94 2 0 {name=l84 lab=vdd}
C {devices/lab_wire.sym} 2380 94 2 0 {name=l85 lab=vdd}
C {devices/lab_wire.sym} -510 354 2 0 {name=l86 lab=vss}
C {devices/lab_wire.sym} -110 260 0 0 {name=l87 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l88 lab=vss}
C {devices/lab_wire.sym} 1810 614 2 0 {name=l89 lab=vss}
C {devices/lab_wire.sym} 365 614 2 0 {name=l90 lab=vss}
C {devices/lab_wire.sym} -510 614 2 0 {name=l91 lab=vss}
C {devices/lab_wire.sym} -170 614 2 0 {name=l92 lab=vss}
C {devices/lab_wire.sym} 160 874 2 0 {name=l93 lab=vss}
C {devices/lab_wire.sym} 725 874 2 0 {name=l94 lab=vss}
C {devices/lab_wire.sym} 160 614 2 0 {name=l95 lab=vss}
C {devices/lab_wire.sym} -720 614 2 0 {name=l96 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l97 lab=vss}
C {devices/lab_wire.sym} 1405 874 2 0 {name=l98 lab=vss}
C {devices/lab_wire.sym} 1065 874 2 0 {name=l99 lab=vss}
C {devices/lab_wire.sym} 1065 614 2 0 {name=l100 lab=vss}
C {devices/lab_wire.sym} 1405 614 2 0 {name=l101 lab=vss}
C {devices/lab_wire.sym} -1915 870 2 0 {name=l102 lab=vss}
C {devices/lab_wire.sym} -1915 690 0 1 {name=l103 lab=net013}
C {devices/lab_wire.sym} 100 610 2 0 {name=l104 lab=vss}
C {devices/iopin.sym} -2030 -140 0 0 {name=p0 lab=vdd}
C {devices/iopin.sym} -2030 920 0 0 {name=p1 lab=vss}
