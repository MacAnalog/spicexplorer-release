v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_017_tan_clia} -1755 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 615 520 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1620 390 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1715 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} -510 260 1 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -1025 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -685 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_nmos_np.sym} -685 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -155 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 185 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 720 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1620 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -685 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -155 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 950 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -155 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1620 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_pmos_np.sym} 185 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -1375 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 720 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1620 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_nmos_np.sym} 550 260 0 1 {name=M61 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 2060 0 0 0 {name=M68 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_nmos_np.sym} 2060 260 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 550 0 0 1 {name=M70 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_nmos_np.sym} 1390 260 0 0 {name=M71 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm71_w l=x_dut_xm71_l m=x_dut_xm71_m}
C {devices/sg13_lv_nmos_np.sym} 1165 260 0 0 {name=M72 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm72_w l=x_dut_xm72_l m=x_dut_xm72_m}
C {devices/sg13_lv_pmos_np.sym} 1165 0 0 0 {name=M73 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm73_w l=x_dut_xm73_l m=x_dut_xm73_m}
C {devices/sg13_lv_pmos_np.sym} 950 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1845 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1715 430 -1715 490 {}
N -1715 550 -1715 610 {}
N -1355 -140 -1355 -30 {}
N -1355 30 -1355 90 {}
N -1295 0 -1295 94 {}
N -1105 0 -1105 94 {}
N -1045 -140 -1045 -30 {}
N -1045 30 -1045 70 {}
N -1005 0 -1005 70 {}
N -765 30 -765 200 {}
N -765 260 -765 354 {}
N -765 520 -765 614 {}
N -705 -140 -705 -30 {}
N -705 30 -705 230 {}
N -705 290 -705 490 {}
N -705 550 -705 660 {}
N -665 0 -665 60 {}
N -665 140 -665 320 {}
N -635 80 -635 580 {}
N -480 260 -480 320 {}
N -235 30 -235 200 {}
N -235 260 -235 354 {}
N -235 520 -235 614 {}
N -175 -140 -175 -30 {}
N -175 30 -175 70 {}
N -175 200 -175 230 {}
N -175 290 -175 490 {}
N -175 550 -175 660 {}
N -135 0 -135 70 {}
N -105 140 -105 260 {}
N -105 520 -105 580 {}
N 165 190 165 260 {}
N 205 -140 205 -30 {}
N 205 30 205 90 {}
N 205 170 205 230 {}
N 205 290 205 660 {}
N 265 0 265 94 {}
N 265 260 265 354 {}
N 470 0 470 94 {}
N 470 260 470 354 {}
N 530 -140 530 -30 {}
N 530 30 530 90 {}
N 530 170 530 230 {}
N 530 290 530 660 {}
N 600 260 600 520 {}
N 615 430 615 490 {}
N 615 550 615 660 {}
N 680 30 680 230 {}
N 700 -60 700 70 {}
N 700 200 700 260 {}
N 740 -140 740 -30 {}
N 740 30 740 70 {}
N 740 290 740 350 {}
N 800 0 800 94 {}
N 800 260 800 354 {}
N 900 520 900 580 {}
N 970 170 970 230 {}
N 970 290 970 490 {}
N 970 550 970 660 {}
N 1030 260 1030 354 {}
N 1030 520 1030 614 {}
N 1145 -60 1145 0 {}
N 1185 -140 1185 -30 {}
N 1185 30 1185 90 {}
N 1185 170 1185 230 {}
N 1185 290 1185 660 {}
N 1245 0 1245 94 {}
N 1245 260 1245 354 {}
N 1370 190 1370 260 {}
N 1410 170 1410 230 {}
N 1410 290 1410 660 {}
N 1470 260 1470 354 {}
N 1570 520 1570 580 {}
N 1620 330 1620 360 {}
N 1620 420 1620 450 {}
N 1640 -140 1640 -30 {}
N 1640 30 1640 90 {}
N 1640 170 1640 230 {}
N 1640 290 1640 490 {}
N 1640 550 1640 660 {}
N 1700 0 1700 94 {}
N 1700 260 1700 354 {}
N 1700 520 1700 614 {}
N 1865 170 1865 230 {}
N 1865 290 1865 320 {}
N 1925 260 1925 354 {}
N 2080 -140 2080 -30 {}
N 2080 30 2080 230 {}
N 2080 290 2080 660 {}
N 2140 0 2140 94 {}
N 2140 260 2140 354 {}
N 2280 200 2280 450 {}
N -1775 -140 2560 -140 {}
N -1455 0 -1395 0 {}
N -1355 0 -1295 0 {}
N -1105 0 -1045 0 {}
N -1005 0 -945 0 {}
N -665 0 -635 0 {}
N -135 0 -75 0 {}
N 105 0 165 0 {}
N 205 0 265 0 {}
N 470 0 530 0 {}
N 570 0 630 0 {}
N 740 0 800 0 {}
N 1115 0 1145 0 {}
N 1185 0 1245 0 {}
N 1540 0 1600 0 {}
N 1640 0 1700 0 {}
N 1980 0 2040 0 {}
N 2080 0 2140 0 {}
N -765 30 -705 30 {}
N -235 30 -175 30 {}
N 680 30 740 30 {}
N -1045 70 -1005 70 {}
N -175 70 -135 70 {}
N 700 70 740 70 {}
N -705 80 -635 80 {}
N -665 140 -105 140 {}
N 165 190 205 190 {}
N 1370 190 1410 190 {}
N -765 200 -705 200 {}
N -235 200 -175 200 {}
N 2080 200 2280 200 {}
N 680 230 740 230 {}
N -765 260 -705 260 {}
N -600 260 -540 260 {}
N -480 260 -450 260 {}
N -235 260 -175 260 {}
N -135 260 -105 260 {}
N 205 260 265 260 {}
N 470 260 530 260 {}
N 570 260 600 260 {}
N 670 260 700 260 {}
N 740 260 800 260 {}
N 840 260 930 260 {}
N 970 260 1030 260 {}
N 1085 260 1145 260 {}
N 1185 260 1245 260 {}
N 1410 260 1470 260 {}
N 1540 260 1600 260 {}
N 1640 260 1700 260 {}
N 1735 260 1825 260 {}
N 1865 260 1925 260 {}
N 1980 260 2040 260 {}
N 2080 260 2140 260 {}
N 740 320 970 320 {}
N 1640 320 1865 320 {}
N 1620 330 1640 330 {}
N 1620 450 2280 450 {}
N -765 520 -705 520 {}
N -665 520 -635 520 {}
N -235 520 -175 520 {}
N -135 520 930 520 {}
N 970 520 1030 520 {}
N 1570 520 1600 520 {}
N 1640 520 1700 520 {}
N -635 580 -105 580 {}
N 900 580 1570 580 {}
N -1775 660 2560 660 {}
C {devices/lab_wire.sym} -75 0 0 1 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 1145 -60 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 740 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -665 320 2 0 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 205 170 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 205 90 2 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 700 200 0 1 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 1540 260 0 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -705 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} 2080 90 2 0 {name=l9 lab=VOUT}
C {devices/lab_wire.sym} 700 -60 0 1 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 1540 0 0 0 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} 630 0 0 1 {name=l12 lab=net050}
C {devices/lab_wire.sym} 1640 90 2 0 {name=l13 lab=net050}
C {devices/lab_wire.sym} 1640 170 0 1 {name=l14 lab=net050}
C {devices/lab_wire.sym} 1980 0 0 0 {name=l15 lab=net050}
C {devices/lab_wire.sym} -1455 0 0 0 {name=l16 lab=net1}
C {devices/lab_wire.sym} -945 0 0 1 {name=l17 lab=net1}
C {devices/lab_wire.sym} -665 60 2 0 {name=l18 lab=net1}
C {devices/lab_wire.sym} 105 0 0 0 {name=l19 lab=net1}
C {devices/lab_wire.sym} -600 260 0 0 {name=l20 lab=net2}
C {devices/lab_wire.sym} 615 430 0 1 {name=l21 lab=net2}
C {devices/lab_wire.sym} 530 90 2 0 {name=l22 lab=net3}
C {devices/lab_wire.sym} 530 170 0 1 {name=l23 lab=net3}
C {devices/lab_wire.sym} 1085 260 0 0 {name=l24 lab=net3}
C {devices/lab_wire.sym} 1410 170 0 1 {name=l25 lab=net3}
C {devices/lab_wire.sym} -1355 90 2 0 {name=l26 lab=net31}
C {devices/lab_wire.sym} 970 170 0 1 {name=l27 lab=net31}
C {devices/lab_wire.sym} 1865 170 0 1 {name=l28 lab=net31}
C {devices/lab_wire.sym} -480 320 2 0 {name=l29 lab=net5}
C {devices/lab_wire.sym} 1185 90 2 0 {name=l30 lab=net5}
C {devices/lab_wire.sym} 1185 170 0 1 {name=l31 lab=net5}
C {devices/lab_wire.sym} 1980 260 0 0 {name=l32 lab=net5}
C {devices/lab_wire.sym} -705 350 2 0 {name=l33 lab=net6}
C {devices/lab_wire.sym} -175 350 2 0 {name=l34 lab=net7}
C {devices/lab_wire.sym} 1640 350 2 0 {name=l35 lab=net8}
C {devices/lab_wire.sym} 1030 354 2 0 {name=l36 lab=net31}
C {devices/lab_wire.sym} 1925 354 2 0 {name=l37 lab=net31}
C {devices/lab_wire.sym} -1105 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} -705 0 0 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} -175 0 0 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 265 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} -1295 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 800 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} 1700 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 2140 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 470 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 1245 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} -765 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} -235 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} 265 354 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} 800 354 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} 1700 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -765 614 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} -235 614 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} 1030 614 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} 1700 614 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} 470 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} 2140 354 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 1470 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} 1245 354 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -1715 610 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} -1715 430 0 1 {name=l62 lab=net1}
C {devices/ipin.sym} 840 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 1735 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1775 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1775 660 0 0 {name=p3 lab=vss}
B 8 -1481 -78 641 78 {fill=0}
T {PMOS Simple Current Mirror (3 outputs)} -1481 -96 0 0 0.3 0.3 {layer=8}
B 10 -1165 182 665 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1165 164 0 0 0.3 0.3 {layer=10}
B 12 -611 -78 1645 78 {fill=0}
T {PMOS Simple Current Mirror} -611 -96 0 0 0.3 0.3 {layer=12}
B 21 650 -78 2076 78 {fill=0}
T {PMOS Simple Current Mirror} 650 -96 0 0 0.3 0.3 {layer=21}
B 15 1095 182 1870 338 {fill=0}
T {NMOS Simple Current Mirror} 1095 164 0 0 0.3 0.3 {layer=15}
B 13 880 182 2301 338 {fill=0}
T {PMOS Differential Pair} 880 164 0 0 0.3 0.3 {layer=13}
