v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_007_leung_dfcfc2} -1910 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 725 260 1 0 {name=C1 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1460 260 1 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1870 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 905 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -510 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 200 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1275 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1640 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -850 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -510 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1275 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1640 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 905 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 540 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} -170 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 200 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 20 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1275 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1640 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 540 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1095 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1830 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1870 430 -1870 490 {}
N -1870 550 -1870 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -930 520 -930 614 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 490 {}
N -870 550 -870 660 {}
N -800 0 -800 60 {}
N -590 0 -590 94 {}
N -590 260 -590 354 {}
N -590 520 -590 614 {}
N -530 -140 -530 -30 {}
N -530 30 -530 90 {}
N -530 170 -530 230 {}
N -530 290 -530 490 {}
N -530 550 -530 660 {}
N -150 -140 -150 -30 {}
N -150 30 -150 90 {}
N -150 170 -150 230 {}
N -150 290 -150 660 {}
N -90 0 -90 94 {}
N -90 260 -90 354 {}
N 0 -60 0 0 {}
N 40 -140 40 -30 {}
N 40 30 40 90 {}
N 100 0 100 94 {}
N 180 -60 180 0 {}
N 180 190 180 260 {}
N 220 -140 220 -30 {}
N 220 30 220 90 {}
N 220 170 220 230 {}
N 220 290 220 660 {}
N 280 0 280 94 {}
N 280 260 280 354 {}
N 560 -140 560 -30 {}
N 560 30 560 90 {}
N 560 170 560 230 {}
N 560 290 560 660 {}
N 620 0 620 94 {}
N 620 260 620 354 {}
N 665 200 665 260 {}
N 785 0 785 260 {}
N 855 260 855 520 {}
N 885 200 885 260 {}
N 925 -140 925 -30 {}
N 925 30 925 90 {}
N 925 170 925 230 {}
N 925 290 925 660 {}
N 985 0 985 94 {}
N 985 260 985 354 {}
N 1075 200 1075 260 {}
N 1115 170 1115 230 {}
N 1115 290 1115 350 {}
N 1175 260 1175 354 {}
N 1255 0 1255 70 {}
N 1255 200 1255 260 {}
N 1295 -140 1295 -30 {}
N 1295 30 1295 70 {}
N 1295 170 1295 230 {}
N 1295 290 1295 490 {}
N 1295 550 1295 660 {}
N 1355 0 1355 94 {}
N 1355 260 1355 354 {}
N 1355 520 1355 614 {}
N 1490 260 1490 320 {}
N 1590 0 1590 60 {}
N 1620 200 1620 260 {}
N 1660 -140 1660 -30 {}
N 1660 30 1660 90 {}
N 1660 170 1660 230 {}
N 1660 290 1660 490 {}
N 1660 550 1660 660 {}
N 1720 0 1720 94 {}
N 1720 260 1720 354 {}
N 1720 520 1720 614 {}
N 1810 200 1810 260 {}
N 1850 170 1850 230 {}
N 1850 290 1850 320 {}
N 1910 260 1910 354 {}
N -1930 -140 2040 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -490 0 -430 0 {}
N -250 0 -190 0 {}
N -150 0 -90 0 {}
N -30 0 0 0 {}
N 40 0 100 0 {}
N 150 0 180 0 {}
N 220 0 280 0 {}
N 460 0 520 0 {}
N 560 0 620 0 {}
N 785 0 885 0 {}
N 925 0 985 0 {}
N 1195 0 1255 0 {}
N 1295 0 1355 0 {}
N 1590 0 1620 0 {}
N 1660 0 1720 0 {}
N 1295 60 1590 60 {}
N -1210 70 -1170 70 {}
N 1255 70 1295 70 {}
N -1550 190 -1510 190 {}
N 180 190 220 190 {}
N -1610 260 -1550 260 {}
N -930 260 -870 260 {}
N -830 260 -770 260 {}
N -590 260 -530 260 {}
N -490 260 -430 260 {}
N -250 260 -190 260 {}
N -150 260 -90 260 {}
N 220 260 280 260 {}
N 460 260 520 260 {}
N 560 260 620 260 {}
N 635 260 695 260 {}
N 755 260 785 260 {}
N 855 260 885 260 {}
N 925 260 985 260 {}
N 1045 260 1075 260 {}
N 1115 260 1175 260 {}
N 1225 260 1255 260 {}
N 1295 260 1355 260 {}
N 1370 260 1430 260 {}
N 1490 260 1520 260 {}
N 1590 260 1620 260 {}
N 1660 260 1720 260 {}
N 1780 260 1810 260 {}
N 1850 260 1910 260 {}
N 1115 320 1295 320 {}
N 1660 320 1850 320 {}
N -930 520 -870 520 {}
N -830 520 -770 520 {}
N -590 520 -530 520 {}
N -490 520 1255 520 {}
N 1295 520 1355 520 {}
N 1560 520 1620 520 {}
N 1660 520 1720 520 {}
N -1930 660 2040 660 {}
C {devices/lab_wire.sym} -1930 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -1930 660 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} -530 90 2 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} -530 170 0 1 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 1115 350 2 0 {name=l4 lab=DM_2}
C {devices/lab_wire.sym} -770 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -430 260 0 1 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 220 170 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 220 90 2 0 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 1255 200 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 1620 200 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -870 90 2 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -870 170 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -770 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 885 200 0 1 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 1560 520 0 0 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1075 200 0 1 {name=l16 lab=VINN}
C {devices/lab_wire.sym} 1810 200 0 1 {name=l17 lab=VINP}
C {devices/lab_wire.sym} -150 90 2 0 {name=l18 lab=VOUT}
C {devices/lab_wire.sym} -150 170 0 1 {name=l19 lab=VOUT}
C {devices/lab_wire.sym} 635 260 0 0 {name=l20 lab=VOUT}
C {devices/lab_wire.sym} 1195 0 0 0 {name=l21 lab=VOUTN}
C {devices/lab_wire.sym} 1295 170 0 1 {name=l22 lab=VOUTN}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l23 lab=net043}
C {devices/lab_wire.sym} 460 260 0 0 {name=l24 lab=net043}
C {devices/lab_wire.sym} -250 260 0 0 {name=l25 lab=net049}
C {devices/lab_wire.sym} 560 90 2 0 {name=l26 lab=net049}
C {devices/lab_wire.sym} 560 170 0 1 {name=l27 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l28 lab=net050}
C {devices/lab_wire.sym} -250 0 0 0 {name=l29 lab=net050}
C {devices/lab_wire.sym} 825 0 0 0 {name=l30 lab=net050}
C {devices/lab_wire.sym} 1490 320 2 0 {name=l31 lab=net050}
C {devices/lab_wire.sym} 1660 90 2 0 {name=l32 lab=net050}
C {devices/lab_wire.sym} 1660 170 0 1 {name=l33 lab=net050}
C {devices/lab_wire.sym} 1660 350 2 0 {name=l34 lab=net063}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l35 lab=net1}
C {devices/lab_wire.sym} -770 0 0 1 {name=l36 lab=net1}
C {devices/lab_wire.sym} -430 0 0 1 {name=l37 lab=net1}
C {devices/lab_wire.sym} 0 -60 0 1 {name=l38 lab=net1}
C {devices/lab_wire.sym} 180 -60 0 1 {name=l39 lab=net1}
C {devices/lab_wire.sym} 460 0 0 0 {name=l40 lab=net1}
C {devices/lab_wire.sym} 925 90 2 0 {name=l41 lab=net2}
C {devices/lab_wire.sym} 925 170 0 1 {name=l42 lab=net2}
C {devices/lab_wire.sym} 1370 260 0 0 {name=l43 lab=net2}
C {devices/lab_wire.sym} 40 90 2 0 {name=l44 lab=net31}
C {devices/lab_wire.sym} 1115 170 0 1 {name=l45 lab=net31}
C {devices/lab_wire.sym} 1850 170 0 1 {name=l46 lab=net31}
C {devices/lab_wire.sym} -870 350 2 0 {name=l47 lab=net54}
C {devices/lab_wire.sym} -530 350 2 0 {name=l48 lab=net56}
C {devices/lab_wire.sym} 1175 354 2 0 {name=l49 lab=net31}
C {devices/lab_wire.sym} 1910 354 2 0 {name=l50 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} 985 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} -90 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -590 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 280 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 100 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 1355 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 1720 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} 620 94 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} -930 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -590 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} 280 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} 1355 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} 1720 354 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} -930 614 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} -590 614 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} 1355 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 1720 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 985 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 620 354 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} -90 354 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} -1870 430 0 1 {name=l75 lab=net1}
C {devices/lab_wire.sym} -1870 610 2 0 {name=l76 lab=vss}
C {devices/ipin.sym} -2070 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -2070 380 0 0 {name=p1 lab=VINP}
