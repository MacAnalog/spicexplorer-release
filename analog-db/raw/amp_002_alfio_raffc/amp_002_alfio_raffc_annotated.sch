v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_002_alfio_raffc} -1785 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1070 390 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1295 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1745 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 625 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 1515 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -500 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -160 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 180 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1070 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1360 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -500 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 180 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -500 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1070 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1855 260 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 1515 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_pmos_np.sym} -160 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 180 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_nmos_np.sym} 625 260 0 0 {name=M59 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 1070 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 1855 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 410 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 850 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1745 430 -1745 490 {}
N -1745 550 -1745 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1440 520 -1440 614 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 490 {}
N -1380 550 -1380 660 {}
N -1340 140 -1340 260 {}
N -1310 -60 -1310 0 {}
N -1310 520 -1310 580 {}
N -1250 200 -1250 520 {}
N -1100 0 -1100 94 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 70 {}
N -1000 -60 -1000 70 {}
N -900 -60 -900 0 {}
N -830 -140 -830 -30 {}
N -830 30 -830 90 {}
N -770 0 -770 94 {}
N -580 0 -580 94 {}
N -580 260 -580 354 {}
N -580 520 -580 614 {}
N -520 -140 -520 -30 {}
N -520 30 -520 90 {}
N -520 170 -520 230 {}
N -520 290 -520 490 {}
N -520 550 -520 660 {}
N -450 -60 -450 0 {}
N -450 140 -450 260 {}
N -450 520 -450 580 {}
N -200 30 -200 200 {}
N -180 190 -180 260 {}
N -140 -140 -140 -30 {}
N -140 30 -140 90 {}
N -140 190 -140 230 {}
N -140 290 -140 660 {}
N -80 0 -80 94 {}
N -80 260 -80 354 {}
N 160 0 160 70 {}
N 200 -140 200 -30 {}
N 200 30 200 70 {}
N 200 170 200 230 {}
N 200 290 200 490 {}
N 200 550 200 660 {}
N 260 0 260 94 {}
N 260 260 260 354 {}
N 260 520 260 614 {}
N 430 200 430 230 {}
N 430 290 430 320 {}
N 490 60 490 200 {}
N 490 260 490 354 {}
N 605 -60 605 0 {}
N 645 -140 645 -30 {}
N 645 30 645 90 {}
N 645 170 645 230 {}
N 645 290 645 660 {}
N 705 0 705 94 {}
N 705 260 705 354 {}
N 870 200 870 230 {}
N 870 290 870 350 {}
N 930 260 930 354 {}
N 1070 320 1070 360 {}
N 1070 420 1070 450 {}
N 1090 -140 1090 -30 {}
N 1090 30 1090 230 {}
N 1090 290 1090 490 {}
N 1090 550 1090 660 {}
N 1150 0 1150 94 {}
N 1150 260 1150 354 {}
N 1150 520 1150 614 {}
N 1295 0 1295 230 {}
N 1295 290 1295 320 {}
N 1495 -60 1495 0 {}
N 1535 -140 1535 -30 {}
N 1535 30 1535 230 {}
N 1535 290 1535 660 {}
N 1595 0 1595 94 {}
N 1595 200 1595 450 {}
N 1805 0 1805 320 {}
N 1835 190 1835 260 {}
N 1875 -140 1875 -30 {}
N 1875 30 1875 230 {}
N 1875 290 1875 660 {}
N 1935 0 1935 94 {}
N 1935 260 1935 354 {}
N -1860 -140 2355 -140 {}
N -1310 -60 -1000 -60 {}
N -900 -60 -450 -60 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1100 0 -1040 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -580 0 -520 0 {}
N -480 0 -180 0 {}
N -140 0 -80 0 {}
N 100 0 160 0 {}
N 200 0 260 0 {}
N 575 0 605 0 {}
N 645 0 705 0 {}
N 990 0 1050 0 {}
N 1090 0 1150 0 {}
N 1295 0 1495 0 {}
N 1535 0 1595 0 {}
N 1775 0 1835 0 {}
N 1875 0 1935 0 {}
N -200 30 -140 30 {}
N -830 60 490 60 {}
N -1040 70 -1000 70 {}
N 160 70 200 70 {}
N -1340 140 -450 140 {}
N -180 190 -140 190 {}
N 1835 190 1875 190 {}
N -1380 200 -1250 200 {}
N -200 200 -140 200 {}
N 370 200 870 200 {}
N 1090 200 1295 200 {}
N 1535 200 1595 200 {}
N -1440 260 -1380 260 {}
N -580 260 -520 260 {}
N -510 260 -180 260 {}
N -140 260 -80 260 {}
N 100 260 160 260 {}
N 200 260 260 260 {}
N 300 260 390 260 {}
N 430 260 490 260 {}
N 545 260 605 260 {}
N 645 260 705 260 {}
N 740 260 830 260 {}
N 870 260 930 260 {}
N 990 260 1050 260 {}
N 1090 260 1150 260 {}
N 1435 260 1495 260 {}
N 1875 260 1935 260 {}
N 200 320 430 320 {}
N 870 320 1090 320 {}
N 1295 320 1805 320 {}
N 1070 450 1595 450 {}
N -1440 520 -1380 520 {}
N -1340 520 -1250 520 {}
N -580 520 -520 520 {}
N -480 520 160 520 {}
N 200 520 260 520 {}
N 990 520 1050 520 {}
N 1090 520 1150 520 {}
N -1310 580 -450 580 {}
N -1860 660 2355 660 {}
C {devices/lab_wire.sym} -520 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -520 170 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 200 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -140 90 2 0 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 100 260 0 0 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 990 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l6 lab=VB4}
C {devices/lab_wire.sym} 545 260 0 0 {name=l7 lab=VB4}
C {devices/lab_wire.sym} 990 520 0 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} 1535 90 2 0 {name=l9 lab=VOUT}
C {devices/lab_wire.sym} 100 0 0 0 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 200 170 0 1 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} 990 0 0 0 {name=l12 lab=VOUTN}
C {devices/lab_wire.sym} 645 90 2 0 {name=l13 lab=net013}
C {devices/lab_wire.sym} 645 170 0 1 {name=l14 lab=net013}
C {devices/lab_wire.sym} 1775 0 0 0 {name=l15 lab=net013}
C {devices/lab_wire.sym} 1435 260 0 0 {name=l16 lab=net043}
C {devices/lab_wire.sym} 1875 90 2 0 {name=l17 lab=net043}
C {devices/lab_wire.sym} 605 -60 0 1 {name=l18 lab=net050}
C {devices/lab_wire.sym} 1495 -60 0 1 {name=l19 lab=net050}
C {devices/lab_wire.sym} 870 350 2 0 {name=l20 lab=net063}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l21 lab=net1}
C {devices/lab_wire.sym} -930 0 0 0 {name=l22 lab=net1}
C {devices/lab_wire.sym} -830 90 2 0 {name=l23 lab=net31}
C {devices/lab_wire.sym} -1380 350 2 0 {name=l24 lab=net54}
C {devices/lab_wire.sym} -520 350 2 0 {name=l25 lab=net56}
C {devices/lab_wire.sym} 490 354 2 0 {name=l26 lab=net31}
C {devices/lab_wire.sym} 930 354 2 0 {name=l27 lab=net31}
C {devices/lab_wire.sym} -1100 94 2 0 {name=l28 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l29 lab=vdd}
C {devices/lab_wire.sym} 705 94 2 0 {name=l30 lab=vdd}
C {devices/lab_wire.sym} 1595 94 2 0 {name=l31 lab=vdd}
C {devices/lab_wire.sym} -580 94 2 0 {name=l32 lab=vdd}
C {devices/lab_wire.sym} -80 94 2 0 {name=l33 lab=vdd}
C {devices/lab_wire.sym} -770 94 2 0 {name=l34 lab=vdd}
C {devices/lab_wire.sym} 260 94 2 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} 1150 94 2 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} 1935 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l38 lab=vss}
C {devices/lab_wire.sym} -580 354 2 0 {name=l39 lab=vss}
C {devices/lab_wire.sym} -80 354 2 0 {name=l40 lab=vss}
C {devices/lab_wire.sym} 260 354 2 0 {name=l41 lab=vss}
C {devices/lab_wire.sym} 1150 354 2 0 {name=l42 lab=vss}
C {devices/lab_wire.sym} -1440 614 2 0 {name=l43 lab=vss}
C {devices/lab_wire.sym} -580 614 2 0 {name=l44 lab=vss}
C {devices/lab_wire.sym} 260 614 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 1150 614 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} 1935 354 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} 1535 260 0 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 705 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} -1745 430 0 1 {name=l50 lab=net1}
C {devices/lab_wire.sym} -1745 610 2 0 {name=l51 lab=vss}
C {devices/ipin.sym} 300 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 740 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -1860 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -1860 660 0 0 {name=p3 lab=vss}
B 8 -1816 -78 296 78 {fill=0}
T {PMOS Simple Current Mirror (4 outputs)} -1816 -96 0 0 0.3 0.3 {layer=8}
B 10 -1840 182 320 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1840 164 0 0 0.3 0.3 {layer=10}
B 12 1445 182 2335 338 {fill=0}
T {NMOS Simple Current Mirror} 1445 164 0 0 0.3 0.3 {layer=12}
B 21 110 -78 1526 78 {fill=0}
T {PMOS Simple Current Mirror} 110 -96 0 0 0.3 0.3 {layer=21}
B 15 340 182 1306 338 {fill=0}
T {PMOS Differential Pair} 340 164 0 0 0.3 0.3 {layer=15}
