v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ia_002_fan_chopper_simple} -3685 -540 0 0 0.4 0.4 {}
C {blocks/tg_pair_cmos_rail_bulk_1.sym} -3425 0 0 0 {name=xtg_pair_cmos_rail_bulk_1}
C {blocks/tg_pair_cmos_rail_bulk_2.sym} -2925 0 0 0 {name=xtg_pair_cmos_rail_bulk_2}
C {blocks/dp_pmos_simple_1.sym} -2455 0 0 0 {name=xdp_pmos_simple_1}
C {blocks/tg_pair_cmos_rail_bulk_3.sym} -1985 0 0 0 {name=xtg_pair_cmos_rail_bulk_3}
C {blocks/dp_nmos_simple_1.sym} -1515 0 0 0 {name=xdp_nmos_simple_1}
C {blocks/tg_pair_cmos_rail_bulk_4.sym} -1045 0 0 0 {name=xtg_pair_cmos_rail_bulk_4}
C {blocks/dp_nmos_simple_2.sym} -575 0 0 0 {name=xdp_nmos_simple_2}
C {blocks/tg_pair_cmos_rail_bulk_5.sym} -105 0 0 0 {name=xtg_pair_cmos_rail_bulk_5}
C {blocks/tg_pair_cmos_rail_bulk_6.sym} 395 0 0 0 {name=xtg_pair_cmos_rail_bulk_6}
C {blocks/tg_pair_cmos_rail_bulk_7.sym} 895 0 0 0 {name=xtg_pair_cmos_rail_bulk_7}
C {blocks/tg_pair_cmos_rail_bulk_8.sym} 1395 0 0 0 {name=xtg_pair_cmos_rail_bulk_8}
C {blocks/tg_pair_cmos_rail_bulk_9.sym} 1895 0 0 0 {name=xtg_pair_cmos_rail_bulk_9}
C {blocks/tg_pair_cmos_rail_bulk_10.sym} 2400 0 0 0 {name=xtg_pair_cmos_rail_bulk_10}
C {blocks/tg_pair_cmos_rail_bulk_11.sym} 2910 0 0 0 {name=xtg_pair_cmos_rail_bulk_11}
C {blocks/tg_pair_cmos_rail_bulk_12.sym} 3420 0 0 0 {name=xtg_pair_cmos_rail_bulk_12}
C {devices/capa_np.sym} -1430 340 0 0 {name=CFB1 value='x_dut_cfb1_value'}
C {devices/capa_np.sym} -1210 340 0 0 {name=CFB2 value='x_dut_cfb2_value'}
C {devices/capa_np.sym} -990 340 0 0 {name=CIN1 value='x_dut_cin1_value'}
C {devices/capa_np.sym} -770 340 0 0 {name=CIN2 value='x_dut_cin2_value'}
C {devices/capa_np.sym} -550 340 0 0 {name=CM1 value='x_dut_cm1_value'}
C {devices/capa_np.sym} -330 340 0 0 {name=CM2 value='x_dut_cm2_value'}
C {devices/res_np.sym} -110 340 0 0 {name=RB1 value='x_dut_rb1_value'}
C {devices/res_np.sym} 110 340 0 0 {name=RB2 value='x_dut_rb2_value'}
C {devices/vsource_np.sym} -3645 340 0 0 {name=VB1 value="dc {vb1}"}
C {devices/vsource_np.sym} -3645 120 0 0 {name=VB2 value="dc {vb2}"}
C {devices/vsource_np.sym} -3645 -100 0 0 {name=VB3 value="dc {vb3}"}
C {devices/vsource_np.sym} -3645 -320 0 0 {name=VB4 value="dc {vb4}"}
C {devices/sg13_lv_pmos_np.sym} -660 -340 0 0 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -440 -340 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -220 -340 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 330 340 0 0 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 550 340 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 770 340 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 990 340 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1210 340 0 0 {name=M4 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_nmos_np.sym} 1430 340 0 0 {name=M5 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 0 -340 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 220 -340 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 440 -340 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 660 -340 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -3565 -20 -3605 -20 {}
C {devices/lab_wire.sym} -3605 -20 0 0 {name=l0 lab=clk_chout}
N -3565 20 -3605 20 {}
C {devices/lab_wire.sym} -3605 20 0 0 {name=l1 lab=clk_chout_not}
N -3285 -20 -3245 -20 {}
C {devices/lab_wire.sym} -3245 -20 0 1 {name=l2 lab=g2_n}
N -3285 20 -3245 20 {}
C {devices/lab_wire.sym} -3245 20 0 1 {name=l3 lab=out1_n}
N -3425 -80 -3425 -120 {}
C {devices/lab_wire.sym} -3425 -120 0 1 {name=l4 lab=vdd}
N -3425 80 -3425 120 {}
C {devices/lab_wire.sym} -3425 120 2 0 {name=l5 lab=vss}
N -3065 -20 -3105 -20 {}
C {devices/lab_wire.sym} -3105 -20 0 0 {name=l6 lab=clk_chout}
N -3065 20 -3105 20 {}
C {devices/lab_wire.sym} -3105 20 0 0 {name=l7 lab=clk_chout_not}
N -2785 -20 -2745 -20 {}
C {devices/lab_wire.sym} -2745 -20 0 1 {name=l8 lab=g2_p}
N -2785 20 -2745 20 {}
C {devices/lab_wire.sym} -2745 20 0 1 {name=l9 lab=out1_p}
N -2925 -80 -2925 -120 {}
C {devices/lab_wire.sym} -2925 -120 0 1 {name=l10 lab=vdd}
N -2925 80 -2925 120 {}
C {devices/lab_wire.sym} -2925 120 2 0 {name=l11 lab=vss}
N -2565 -20 -2605 -20 {}
C {devices/lab_wire.sym} -2605 -20 0 0 {name=l12 lab=vsum_n}
N -2565 20 -2605 20 {}
C {devices/lab_wire.sym} -2605 20 0 0 {name=l13 lab=vsum_p}
N -2345 -40 -2305 -40 {}
C {devices/lab_wire.sym} -2305 -40 0 1 {name=l14 lab=fold_n}
N -2345 0 -2305 0 {}
C {devices/lab_wire.sym} -2305 0 0 1 {name=l15 lab=fold_p}
N -2345 40 -2305 40 {}
C {devices/lab_wire.sym} -2305 40 0 1 {name=l16 lab=tail}
N -2455 -100 -2455 -140 {}
C {devices/lab_wire.sym} -2455 -140 0 1 {name=l17 lab=vdd}
N -2125 -20 -2165 -20 {}
C {devices/lab_wire.sym} -2165 -20 0 0 {name=l18 lab=clk_chfb}
N -2125 20 -2165 20 {}
C {devices/lab_wire.sym} -2165 20 0 0 {name=l19 lab=clk_chfb_not}
N -1845 -20 -1805 -20 {}
C {devices/lab_wire.sym} -1805 -20 0 1 {name=l20 lab=fbch_p}
N -1845 20 -1805 20 {}
C {devices/lab_wire.sym} -1805 20 0 1 {name=l21 lab=voutp}
N -1985 -80 -1985 -120 {}
C {devices/lab_wire.sym} -1985 -120 0 1 {name=l22 lab=vdd}
N -1985 80 -1985 120 {}
C {devices/lab_wire.sym} -1985 120 2 0 {name=l23 lab=vss}
N -1625 -20 -1665 -20 {}
C {devices/lab_wire.sym} -1665 -20 0 0 {name=l24 lab=clk_chfb}
N -1625 20 -1665 20 {}
C {devices/lab_wire.sym} -1665 20 0 0 {name=l25 lab=clk_chfb_not}
N -1405 -40 -1365 -40 {}
C {devices/lab_wire.sym} -1365 -40 0 1 {name=l26 lab=fbch_n}
N -1405 0 -1365 0 {}
C {devices/lab_wire.sym} -1365 0 0 1 {name=l27 lab=fbch_p}
N -1405 40 -1365 40 {}
C {devices/lab_wire.sym} -1365 40 0 1 {name=l28 lab=voutp}
N -1515 100 -1515 140 {}
C {devices/lab_wire.sym} -1515 140 2 0 {name=l29 lab=vss}
N -1185 -20 -1225 -20 {}
C {devices/lab_wire.sym} -1225 -20 0 0 {name=l30 lab=clk_chfb}
N -1185 20 -1225 20 {}
C {devices/lab_wire.sym} -1225 20 0 0 {name=l31 lab=clk_chfb_not}
N -905 -20 -865 -20 {}
C {devices/lab_wire.sym} -865 -20 0 1 {name=l32 lab=fbch_n}
N -905 20 -865 20 {}
C {devices/lab_wire.sym} -865 20 0 1 {name=l33 lab=voutn}
N -1045 -80 -1045 -120 {}
C {devices/lab_wire.sym} -1045 -120 0 1 {name=l34 lab=vdd}
N -1045 80 -1045 120 {}
C {devices/lab_wire.sym} -1045 120 2 0 {name=l35 lab=vss}
N -685 -20 -725 -20 {}
C {devices/lab_wire.sym} -725 -20 0 0 {name=l36 lab=clk_chfb}
N -685 20 -725 20 {}
C {devices/lab_wire.sym} -725 20 0 0 {name=l37 lab=clk_chfb_not}
N -465 -40 -425 -40 {}
C {devices/lab_wire.sym} -425 -40 0 1 {name=l38 lab=fbch_n}
N -465 0 -425 0 {}
C {devices/lab_wire.sym} -425 0 0 1 {name=l39 lab=fbch_p}
N -465 40 -425 40 {}
C {devices/lab_wire.sym} -425 40 0 1 {name=l40 lab=voutn}
N -575 100 -575 140 {}
C {devices/lab_wire.sym} -575 140 2 0 {name=l41 lab=vss}
N -245 -20 -285 -20 {}
C {devices/lab_wire.sym} -285 -20 0 0 {name=l42 lab=clk_chin}
N -245 20 -285 20 {}
C {devices/lab_wire.sym} -285 20 0 0 {name=l43 lab=clk_chin_not}
N 35 -20 75 -20 {}
C {devices/lab_wire.sym} 75 -20 0 1 {name=l44 lab=inch_n}
N 35 20 75 20 {}
C {devices/lab_wire.sym} 75 20 0 1 {name=l45 lab=vinn}
N -105 -80 -105 -120 {}
C {devices/lab_wire.sym} -105 -120 0 1 {name=l46 lab=vdd}
N -105 80 -105 120 {}
C {devices/lab_wire.sym} -105 120 2 0 {name=l47 lab=vss}
N 255 -20 215 -20 {}
C {devices/lab_wire.sym} 215 -20 0 0 {name=l48 lab=clk_chin}
N 255 20 215 20 {}
C {devices/lab_wire.sym} 215 20 0 0 {name=l49 lab=clk_chin_not}
N 535 -20 575 -20 {}
C {devices/lab_wire.sym} 575 -20 0 1 {name=l50 lab=inch_p}
N 535 20 575 20 {}
C {devices/lab_wire.sym} 575 20 0 1 {name=l51 lab=vinp}
N 395 -80 395 -120 {}
C {devices/lab_wire.sym} 395 -120 0 1 {name=l52 lab=vdd}
N 395 80 395 120 {}
C {devices/lab_wire.sym} 395 120 2 0 {name=l53 lab=vss}
N 755 -20 715 -20 {}
C {devices/lab_wire.sym} 715 -20 0 0 {name=l54 lab=clk_chout}
N 755 20 715 20 {}
C {devices/lab_wire.sym} 715 20 0 0 {name=l55 lab=clk_chout_not}
N 1035 -20 1075 -20 {}
C {devices/lab_wire.sym} 1075 -20 0 1 {name=l56 lab=g2_p}
N 1035 20 1075 20 {}
C {devices/lab_wire.sym} 1075 20 0 1 {name=l57 lab=out1_n}
N 895 -80 895 -120 {}
C {devices/lab_wire.sym} 895 -120 0 1 {name=l58 lab=vdd}
N 895 80 895 120 {}
C {devices/lab_wire.sym} 895 120 2 0 {name=l59 lab=vss}
N 1255 -20 1215 -20 {}
C {devices/lab_wire.sym} 1215 -20 0 0 {name=l60 lab=clk_chout}
N 1255 20 1215 20 {}
C {devices/lab_wire.sym} 1215 20 0 0 {name=l61 lab=clk_chout_not}
N 1535 -20 1575 -20 {}
C {devices/lab_wire.sym} 1575 -20 0 1 {name=l62 lab=g2_n}
N 1535 20 1575 20 {}
C {devices/lab_wire.sym} 1575 20 0 1 {name=l63 lab=out1_p}
N 1395 -80 1395 -120 {}
C {devices/lab_wire.sym} 1395 -120 0 1 {name=l64 lab=vdd}
N 1395 80 1395 120 {}
C {devices/lab_wire.sym} 1395 120 2 0 {name=l65 lab=vss}
N 1755 -20 1715 -20 {}
C {devices/lab_wire.sym} 1715 -20 0 0 {name=l66 lab=clk_chin}
N 1755 20 1715 20 {}
C {devices/lab_wire.sym} 1715 20 0 0 {name=l67 lab=clk_chin_not}
N 2035 -20 2075 -20 {}
C {devices/lab_wire.sym} 2075 -20 0 1 {name=l68 lab=inch_p}
N 2035 20 2075 20 {}
C {devices/lab_wire.sym} 2075 20 0 1 {name=l69 lab=vinn}
N 1895 -80 1895 -120 {}
C {devices/lab_wire.sym} 1895 -120 0 1 {name=l70 lab=vdd}
N 1895 80 1895 120 {}
C {devices/lab_wire.sym} 1895 120 2 0 {name=l71 lab=vss}
N 2255 -20 2215 -20 {}
C {devices/lab_wire.sym} 2215 -20 0 0 {name=l72 lab=clk_chin}
N 2255 20 2215 20 {}
C {devices/lab_wire.sym} 2215 20 0 0 {name=l73 lab=clk_chin_not}
N 2545 -20 2585 -20 {}
C {devices/lab_wire.sym} 2585 -20 0 1 {name=l74 lab=inch_n}
N 2545 20 2585 20 {}
C {devices/lab_wire.sym} 2585 20 0 1 {name=l75 lab=vinp}
N 2400 -80 2400 -120 {}
C {devices/lab_wire.sym} 2400 -120 0 1 {name=l76 lab=vdd}
N 2400 80 2400 120 {}
C {devices/lab_wire.sym} 2400 120 2 0 {name=l77 lab=vss}
N 2765 -20 2725 -20 {}
C {devices/lab_wire.sym} 2725 -20 0 0 {name=l78 lab=clk_chfb}
N 2765 20 2725 20 {}
C {devices/lab_wire.sym} 2725 20 0 0 {name=l79 lab=clk_chfb_not}
N 3055 -20 3095 -20 {}
C {devices/lab_wire.sym} 3095 -20 0 1 {name=l80 lab=fbch_p}
N 3055 20 3095 20 {}
C {devices/lab_wire.sym} 3095 20 0 1 {name=l81 lab=voutn}
N 2910 -80 2910 -120 {}
C {devices/lab_wire.sym} 2910 -120 0 1 {name=l82 lab=vdd}
N 2910 80 2910 120 {}
C {devices/lab_wire.sym} 2910 120 2 0 {name=l83 lab=vss}
N 3275 -20 3235 -20 {}
C {devices/lab_wire.sym} 3235 -20 0 0 {name=l84 lab=clk_chfb}
N 3275 20 3235 20 {}
C {devices/lab_wire.sym} 3235 20 0 0 {name=l85 lab=clk_chfb_not}
N 3565 -20 3605 -20 {}
C {devices/lab_wire.sym} 3605 -20 0 1 {name=l86 lab=fbch_n}
N 3565 20 3605 20 {}
C {devices/lab_wire.sym} 3605 20 0 1 {name=l87 lab=voutp}
N 3420 -80 3420 -120 {}
C {devices/lab_wire.sym} 3420 -120 0 1 {name=l88 lab=vdd}
N 3420 80 3420 120 {}
C {devices/lab_wire.sym} 3420 120 2 0 {name=l89 lab=vss}
N -1430 310 -1430 270 {}
C {devices/lab_wire.sym} -1430 270 0 1 {name=l90 lab=fbch_p}
N -1430 370 -1430 410 {}
C {devices/lab_wire.sym} -1430 410 2 0 {name=l91 lab=vsum_n}
N -1210 310 -1210 270 {}
C {devices/lab_wire.sym} -1210 270 0 1 {name=l92 lab=fbch_n}
N -1210 370 -1210 410 {}
C {devices/lab_wire.sym} -1210 410 2 0 {name=l93 lab=vsum_p}
N -990 310 -990 270 {}
C {devices/lab_wire.sym} -990 270 0 1 {name=l94 lab=vsum_n}
N -990 370 -990 410 {}
C {devices/lab_wire.sym} -990 410 2 0 {name=l95 lab=inch_n}
N -770 310 -770 270 {}
C {devices/lab_wire.sym} -770 270 0 1 {name=l96 lab=vsum_p}
N -770 370 -770 410 {}
C {devices/lab_wire.sym} -770 410 2 0 {name=l97 lab=inch_p}
N -550 310 -550 270 {}
C {devices/lab_wire.sym} -550 270 0 1 {name=l98 lab=g2_p}
N -550 370 -550 410 {}
C {devices/lab_wire.sym} -550 410 2 0 {name=l99 lab=voutp}
N -330 310 -330 270 {}
C {devices/lab_wire.sym} -330 270 0 1 {name=l100 lab=g2_n}
N -330 370 -330 410 {}
C {devices/lab_wire.sym} -330 410 2 0 {name=l101 lab=voutn}
N -110 310 -110 270 {}
C {devices/lab_wire.sym} -110 270 0 1 {name=l102 lab=vsum_n}
N -110 370 -110 410 {}
C {devices/lab_wire.sym} -110 410 2 0 {name=l103 lab=vref}
N 110 310 110 270 {}
C {devices/lab_wire.sym} 110 270 0 1 {name=l104 lab=vsum_p}
N 110 370 110 410 {}
C {devices/lab_wire.sym} 110 410 2 0 {name=l105 lab=vref}
N -3645 310 -3645 270 {}
C {devices/lab_wire.sym} -3645 270 0 1 {name=l106 lab=vb1}
N -3645 370 -3645 410 {}
C {devices/lab_wire.sym} -3645 410 2 0 {name=l107 lab=vss}
N -3645 90 -3645 50 {}
C {devices/lab_wire.sym} -3645 50 0 1 {name=l108 lab=vb2}
N -3645 150 -3645 190 {}
C {devices/lab_wire.sym} -3645 190 2 0 {name=l109 lab=vss}
N -3645 -130 -3645 -170 {}
C {devices/lab_wire.sym} -3645 -170 0 1 {name=l110 lab=vb3}
N -3645 -70 -3645 -30 {}
C {devices/lab_wire.sym} -3645 -30 2 0 {name=l111 lab=vss}
N -3645 -350 -3645 -390 {}
C {devices/lab_wire.sym} -3645 -390 0 1 {name=l112 lab=vb4}
N -3645 -290 -3645 -250 {}
C {devices/lab_wire.sym} -3645 -250 2 0 {name=l113 lab=vss}
N -640 -310 -640 -270 {}
C {devices/lab_wire.sym} -640 -270 2 0 {name=l114 lab=tail}
N -680 -340 -720 -340 {}
C {devices/lab_wire.sym} -720 -340 0 0 {name=l115 lab=vb4}
N -640 -370 -640 -410 {}
C {devices/lab_wire.sym} -640 -410 0 1 {name=l116 lab=vdd}
N -640 -340 -600 -340 {}
C {devices/lab_wire.sym} -600 -340 0 1 {name=l117 lab=vdd}
N -420 -310 -420 -270 {}
C {devices/lab_wire.sym} -420 -270 2 0 {name=l118 lab=out1_n}
N -460 -340 -500 -340 {}
C {devices/lab_wire.sym} -500 -340 0 0 {name=l119 lab=vb3}
N -420 -370 -420 -410 {}
C {devices/lab_wire.sym} -420 -410 0 1 {name=l120 lab=casc_src_n}
N -420 -340 -380 -340 {}
C {devices/lab_wire.sym} -380 -340 0 1 {name=l121 lab=vdd}
N -200 -310 -200 -270 {}
C {devices/lab_wire.sym} -200 -270 2 0 {name=l122 lab=out1_p}
N -240 -340 -280 -340 {}
C {devices/lab_wire.sym} -280 -340 0 0 {name=l123 lab=vb3}
N -200 -370 -200 -410 {}
C {devices/lab_wire.sym} -200 -410 0 1 {name=l124 lab=casc_src_p}
N -200 -340 -160 -340 {}
C {devices/lab_wire.sym} -160 -340 0 1 {name=l125 lab=vdd}
N 350 310 350 270 {}
C {devices/lab_wire.sym} 350 270 0 1 {name=l126 lab=out1_p}
N 310 340 270 340 {}
C {devices/lab_wire.sym} 270 340 0 0 {name=l127 lab=vb2}
N 350 370 350 410 {}
C {devices/lab_wire.sym} 350 410 2 0 {name=l128 lab=fold_p}
N 350 340 390 340 {}
C {devices/lab_wire.sym} 390 340 0 1 {name=l129 lab=vss}
N 570 310 570 270 {}
C {devices/lab_wire.sym} 570 270 0 1 {name=l130 lab=out1_n}
N 530 340 490 340 {}
C {devices/lab_wire.sym} 490 340 0 0 {name=l131 lab=vb2}
N 570 370 570 410 {}
C {devices/lab_wire.sym} 570 410 2 0 {name=l132 lab=fold_n}
N 570 340 610 340 {}
C {devices/lab_wire.sym} 610 340 0 1 {name=l133 lab=vss}
N 790 310 790 270 {}
C {devices/lab_wire.sym} 790 270 0 1 {name=l134 lab=voutp}
N 750 340 710 340 {}
C {devices/lab_wire.sym} 710 340 0 0 {name=l135 lab=g2_p}
N 790 370 790 410 {}
C {devices/lab_wire.sym} 790 410 2 0 {name=l136 lab=vss}
N 790 340 830 340 {}
C {devices/lab_wire.sym} 830 340 0 1 {name=l137 lab=vss}
N 1010 310 1010 270 {}
C {devices/lab_wire.sym} 1010 270 0 1 {name=l138 lab=voutn}
N 970 340 930 340 {}
C {devices/lab_wire.sym} 930 340 0 0 {name=l139 lab=g2_n}
N 1010 370 1010 410 {}
C {devices/lab_wire.sym} 1010 410 2 0 {name=l140 lab=vss}
N 1010 340 1050 340 {}
C {devices/lab_wire.sym} 1050 340 0 1 {name=l141 lab=vss}
N 1230 310 1230 270 {}
C {devices/lab_wire.sym} 1230 270 0 1 {name=l142 lab=fold_p}
N 1190 340 1150 340 {}
C {devices/lab_wire.sym} 1150 340 0 0 {name=l143 lab=vb1}
N 1230 370 1230 410 {}
C {devices/lab_wire.sym} 1230 410 2 0 {name=l144 lab=vss}
N 1230 340 1270 340 {}
C {devices/lab_wire.sym} 1270 340 0 1 {name=l145 lab=vss}
N 1450 310 1450 270 {}
C {devices/lab_wire.sym} 1450 270 0 1 {name=l146 lab=fold_n}
N 1410 340 1370 340 {}
C {devices/lab_wire.sym} 1370 340 0 0 {name=l147 lab=vb1}
N 1450 370 1450 410 {}
C {devices/lab_wire.sym} 1450 410 2 0 {name=l148 lab=vss}
N 1450 340 1490 340 {}
C {devices/lab_wire.sym} 1490 340 0 1 {name=l149 lab=vss}
N 20 -310 20 -270 {}
C {devices/lab_wire.sym} 20 -270 2 0 {name=l150 lab=casc_src_n}
N -20 -340 -60 -340 {}
C {devices/lab_wire.sym} -60 -340 0 0 {name=l151 lab=vb4}
N 20 -370 20 -410 {}
C {devices/lab_wire.sym} 20 -410 0 1 {name=l152 lab=vdd}
N 20 -340 60 -340 {}
C {devices/lab_wire.sym} 60 -340 0 1 {name=l153 lab=vdd}
N 240 -310 240 -270 {}
C {devices/lab_wire.sym} 240 -270 2 0 {name=l154 lab=casc_src_p}
N 200 -340 160 -340 {}
C {devices/lab_wire.sym} 160 -340 0 0 {name=l155 lab=vb4}
N 240 -370 240 -410 {}
C {devices/lab_wire.sym} 240 -410 0 1 {name=l156 lab=vdd}
N 240 -340 280 -340 {}
C {devices/lab_wire.sym} 280 -340 0 1 {name=l157 lab=vdd}
N 460 -310 460 -270 {}
C {devices/lab_wire.sym} 460 -270 2 0 {name=l158 lab=voutp}
N 420 -340 380 -340 {}
C {devices/lab_wire.sym} 380 -340 0 0 {name=l159 lab=vb4}
N 460 -370 460 -410 {}
C {devices/lab_wire.sym} 460 -410 0 1 {name=l160 lab=vdd}
N 460 -340 500 -340 {}
C {devices/lab_wire.sym} 500 -340 0 1 {name=l161 lab=vdd}
N 680 -310 680 -270 {}
C {devices/lab_wire.sym} 680 -270 2 0 {name=l162 lab=voutn}
N 640 -340 600 -340 {}
C {devices/lab_wire.sym} 600 -340 0 0 {name=l163 lab=vb4}
N 680 -370 680 -410 {}
C {devices/lab_wire.sym} 680 -410 0 1 {name=l164 lab=vdd}
N 680 -340 720 -340 {}
C {devices/lab_wire.sym} 720 -340 0 1 {name=l165 lab=vdd}
