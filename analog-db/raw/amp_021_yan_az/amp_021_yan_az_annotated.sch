v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_021_yan_az} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 875 390 1 0 {name=C0 value='CAPACITOR_1'}
C {devices/capa_np.sym} 640 520 0 0 {name=C1 value='CAPACITOR_0'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_1_BIAS'}
C {devices/res_np.sym} -850 390 1 0 {name=R0 value='RESISTOR_1'}
C {devices/res_np.sym} -640 390 1 0 {name=R1 value='RESISTOR_2'}
C {devices/res_np.sym} 865 260 0 0 {name=R2 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -460 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1745 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 640 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 300 0 0 1 {name=M13 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 1075 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1520 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 300 260 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -460 260 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -240 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1075 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1520 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 640 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 1970 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} -60 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 1075 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1520 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1970 0 0 0 {name=M67 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm67_w l=x_dut_xm67_l m=x_dut_xm67_m}
C {devices/sg13_lv_pmos_np.sym} 1300 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 390 -1610 460 {}
N -1610 520 -1610 614 {}
N -1550 460 -1550 490 {}
N -1550 550 -1550 660 {}
N -1270 520 -1270 614 {}
N -1210 430 -1210 490 {}
N -1210 550 -1210 660 {}
N -930 0 -930 94 {}
N -870 -140 -870 -30 {}
N -870 30 -870 70 {}
N -830 0 -830 70 {}
N -820 390 -820 450 {}
N -790 330 -790 390 {}
N -580 330 -580 390 {}
N -540 0 -540 94 {}
N -540 260 -540 354 {}
N -480 -140 -480 -30 {}
N -480 30 -480 90 {}
N -480 170 -480 230 {}
N -480 290 -480 660 {}
N -440 190 -440 260 {}
N -410 -60 -410 0 {}
N -320 0 -320 94 {}
N -260 -140 -260 -30 {}
N -260 30 -260 90 {}
N -190 -60 -190 0 {}
N -40 -140 -40 -30 {}
N -40 30 -40 90 {}
N 20 0 20 94 {}
N 220 0 220 94 {}
N 220 230 220 390 {}
N 280 -140 280 -30 {}
N 280 30 280 90 {}
N 280 170 280 230 {}
N 280 290 280 660 {}
N 290 200 290 260 {}
N 530 0 530 60 {}
N 600 30 600 230 {}
N 640 260 640 490 {}
N 640 550 640 660 {}
N 660 -140 660 -30 {}
N 660 30 660 90 {}
N 660 290 660 660 {}
N 720 0 720 94 {}
N 720 260 720 354 {}
N 865 290 865 460 {}
N 935 390 935 520 {}
N 1025 520 1025 580 {}
N 1055 0 1055 70 {}
N 1095 -140 1095 -30 {}
N 1095 30 1095 70 {}
N 1095 290 1095 490 {}
N 1095 550 1095 660 {}
N 1155 30 1155 230 {}
N 1155 260 1155 354 {}
N 1155 520 1155 614 {}
N 1320 170 1320 230 {}
N 1320 290 1320 320 {}
N 1380 260 1380 354 {}
N 1470 520 1470 580 {}
N 1500 -60 1500 0 {}
N 1540 -140 1540 -30 {}
N 1540 30 1540 60 {}
N 1540 170 1540 230 {}
N 1540 290 1540 490 {}
N 1540 550 1540 660 {}
N 1600 0 1600 94 {}
N 1600 260 1600 354 {}
N 1600 520 1600 614 {}
N 1765 170 1765 230 {}
N 1765 290 1765 320 {}
N 1825 260 1825 354 {}
N 1950 -60 1950 0 {}
N 1990 -140 1990 -30 {}
N 1990 30 1990 230 {}
N 1990 290 1990 660 {}
N 2050 0 2050 94 {}
N 2050 260 2050 354 {}
N -2030 -140 2470 -140 {}
N -410 -60 -190 -60 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -540 0 -480 0 {}
N -440 0 -380 0 {}
N -320 0 -260 0 {}
N -220 0 -80 0 {}
N -40 0 20 0 {}
N 220 0 280 0 {}
N 320 0 620 0 {}
N 660 0 720 0 {}
N 995 0 1055 0 {}
N 1470 0 1500 0 {}
N 1540 0 1600 0 {}
N 1920 0 1950 0 {}
N 1990 0 2050 0 {}
N 600 30 660 30 {}
N 1095 30 1155 30 {}
N 530 60 1540 60 {}
N -870 70 -830 70 {}
N 1055 70 1095 70 {}
N -480 190 -440 190 {}
N 290 200 1990 200 {}
N 220 230 280 230 {}
N 600 230 865 230 {}
N 1095 230 1155 230 {}
N -540 260 -480 260 {}
N 290 260 350 260 {}
N 560 260 640 260 {}
N 660 260 720 260 {}
N 995 260 1055 260 {}
N 1095 260 1155 260 {}
N 1190 260 1280 260 {}
N 1320 260 1380 260 {}
N 1440 260 1500 260 {}
N 1540 260 1600 260 {}
N 1635 260 1725 260 {}
N 1765 260 1825 260 {}
N 1890 260 1950 260 {}
N 1990 260 2050 260 {}
N 1095 320 1320 320 {}
N 1540 320 1765 320 {}
N -790 330 -580 330 {}
N -1610 390 -880 390 {}
N -820 390 -790 390 {}
N -730 390 -670 390 {}
N -610 390 -580 390 {}
N 220 390 845 390 {}
N 905 390 1540 390 {}
N -1610 460 -1550 460 {}
N 640 460 865 460 {}
N -1610 520 -1550 520 {}
N -1510 520 -1450 520 {}
N -1270 520 -1210 520 {}
N -1170 520 935 520 {}
N 995 520 1055 520 {}
N 1095 520 1155 520 {}
N 1470 520 1500 520 {}
N 1540 520 1600 520 {}
N 1025 580 1470 580 {}
N -2030 660 2470 660 {}
C {devices/lab_wire.sym} -1450 520 0 1 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} 1095 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -770 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} -380 0 0 1 {name=l3 lab=VB1}
C {devices/lab_wire.sym} -480 90 2 0 {name=l4 lab=VB4}
C {devices/lab_wire.sym} -480 170 0 1 {name=l5 lab=VB4}
C {devices/lab_wire.sym} 995 520 0 0 {name=l6 lab=VB4}
C {devices/lab_wire.sym} 280 90 2 0 {name=l7 lab=VOUT}
C {devices/lab_wire.sym} 280 170 0 1 {name=l8 lab=VOUT}
C {devices/lab_wire.sym} 995 0 0 0 {name=l9 lab=VOUTN}
C {devices/lab_wire.sym} 1500 -60 0 1 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 1950 -60 0 1 {name=l11 lab=VOUTN}
C {devices/lab_wire.sym} -260 90 2 0 {name=l12 lab=net019}
C {devices/lab_wire.sym} 1320 170 0 1 {name=l13 lab=net019}
C {devices/lab_wire.sym} 1765 170 0 1 {name=l14 lab=net019}
C {devices/lab_wire.sym} 380 0 0 1 {name=l15 lab=net050}
C {devices/lab_wire.sym} 1540 170 0 1 {name=l16 lab=net050}
C {devices/lab_wire.sym} 560 260 0 0 {name=l17 lab=net051}
C {devices/lab_wire.sym} 1990 90 2 0 {name=l18 lab=net057}
C {devices/lab_wire.sym} 1540 350 2 0 {name=l19 lab=net063}
C {devices/lab_wire.sym} -940 390 0 0 {name=l20 lab=net077}
C {devices/lab_wire.sym} 995 260 0 0 {name=l21 lab=net077}
C {devices/lab_wire.sym} -820 450 2 0 {name=l22 lab=net078}
C {devices/lab_wire.sym} -40 90 2 0 {name=l23 lab=net078}
C {devices/lab_wire.sym} -1210 430 0 1 {name=l24 lab=net082}
C {devices/lab_wire.sym} -730 390 0 0 {name=l25 lab=net082}
C {devices/lab_wire.sym} 1440 260 0 0 {name=l26 lab=net082}
C {devices/lab_wire.sym} 660 90 2 0 {name=l27 lab=net094}
C {devices/lab_wire.sym} 1890 260 0 0 {name=l28 lab=net094}
C {devices/lab_wire.sym} 1825 354 2 0 {name=l29 lab=net019}
C {devices/lab_wire.sym} 1380 354 2 0 {name=l30 lab=net019}
C {devices/lab_wire.sym} -930 94 2 0 {name=l31 lab=vdd}
C {devices/lab_wire.sym} -540 94 2 0 {name=l32 lab=vdd}
C {devices/lab_wire.sym} 720 94 2 0 {name=l33 lab=vdd}
C {devices/lab_wire.sym} 220 94 2 0 {name=l34 lab=vdd}
C {devices/lab_wire.sym} -320 94 2 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} 20 94 2 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} 1095 0 0 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} 1600 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} 2050 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 1155 354 2 0 {name=l40 lab=vss}
C {devices/lab_wire.sym} 1600 354 2 0 {name=l41 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l42 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l43 lab=vss}
C {devices/lab_wire.sym} 280 260 0 0 {name=l44 lab=vss}
C {devices/lab_wire.sym} -540 354 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 1155 614 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} 1600 614 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} 720 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 2050 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l51 lab=VB1}
C {devices/ipin.sym} 1190 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 1635 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
B 8 -1306 -78 396 78 {fill=0}
T {PMOS Simple Current Mirror (3 outputs)} -1306 -96 0 0 0.3 0.3 {layer=8}
B 10 -940 182 2000 598 {fill=0}
T {NMOS Simple Current Mirror (2 outputs)} -940 164 0 0 0.3 0.3 {layer=10}
B 12 1005 -78 2450 78 {fill=0}
T {PMOS Simple Current Mirror (2 outputs)} 1005 -96 0 0 0.3 0.3 {layer=12}
B 21 1230 182 2225 338 {fill=0}
T {PMOS Differential Pair} 1230 164 0 0 0.3 0.3 {layer=21}
