v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_007_leung_dfcfc2} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 840 260 1 0 {name=C1 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1730 260 1 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1060 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -510 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 275 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1500 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1945 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -850 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -510 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1500 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1945 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 1060 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 615 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} -170 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 275 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 55 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1500 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1945 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 615 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1285 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2170 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -930 520 -930 614 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 490 {}
N -870 550 -870 660 {}
N -830 200 -830 260 {}
N -800 -60 -800 0 {}
N -800 520 -800 580 {}
N -590 60 -590 230 {}
N -590 260 -590 354 {}
N -590 520 -590 614 {}
N -530 -140 -530 -30 {}
N -530 30 -530 90 {}
N -530 290 -530 490 {}
N -530 550 -530 660 {}
N -460 -60 -460 0 {}
N -460 200 -460 260 {}
N -460 520 -460 580 {}
N -210 60 -210 230 {}
N -150 -140 -150 -30 {}
N -150 30 -150 90 {}
N -150 290 -150 660 {}
N -90 0 -90 94 {}
N -90 260 -90 354 {}
N 75 -140 75 -30 {}
N 75 30 75 90 {}
N 135 0 135 94 {}
N 255 190 255 260 {}
N 295 -140 295 -30 {}
N 295 30 295 90 {}
N 295 170 295 230 {}
N 295 290 295 660 {}
N 355 0 355 94 {}
N 355 260 355 354 {}
N 635 -140 635 -30 {}
N 635 30 635 90 {}
N 635 170 635 230 {}
N 635 290 635 660 {}
N 695 0 695 94 {}
N 695 260 695 354 {}
N 900 0 900 260 {}
N 1010 260 1010 520 {}
N 1040 -60 1040 0 {}
N 1080 -140 1080 -30 {}
N 1080 30 1080 90 {}
N 1080 200 1080 230 {}
N 1080 290 1080 660 {}
N 1140 30 1140 200 {}
N 1140 260 1140 354 {}
N 1305 170 1305 230 {}
N 1305 290 1305 350 {}
N 1365 260 1365 354 {}
N 1450 520 1450 580 {}
N 1480 0 1480 70 {}
N 1520 -140 1520 -30 {}
N 1520 30 1520 70 {}
N 1520 170 1520 230 {}
N 1520 290 1520 490 {}
N 1520 550 1520 660 {}
N 1580 0 1580 94 {}
N 1580 260 1580 354 {}
N 1580 520 1580 614 {}
N 1760 260 1760 320 {}
N 1895 0 1895 60 {}
N 1895 520 1895 580 {}
N 1965 -140 1965 -30 {}
N 1965 30 1965 90 {}
N 1965 290 1965 490 {}
N 1965 550 1965 660 {}
N 2025 60 2025 230 {}
N 2025 260 2025 354 {}
N 2025 520 2025 614 {}
N 2190 170 2190 230 {}
N 2190 290 2190 320 {}
N 2250 260 2250 354 {}
N -2030 -140 2645 -140 {}
N -800 -60 -460 -60 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -490 0 -460 0 {}
N -250 0 -190 0 {}
N -150 0 -90 0 {}
N -25 0 35 0 {}
N 75 0 135 0 {}
N 195 0 255 0 {}
N 295 0 355 0 {}
N 535 0 595 0 {}
N 635 0 695 0 {}
N 900 0 1040 0 {}
N 1420 0 1480 0 {}
N 1520 0 1580 0 {}
N 1895 0 1925 0 {}
N 1080 30 1140 30 {}
N -590 60 -530 60 {}
N -210 60 -150 60 {}
N 1520 60 1895 60 {}
N 1965 60 2025 60 {}
N -1210 70 -1170 70 {}
N 1480 70 1520 70 {}
N -1550 190 -1510 190 {}
N 255 190 295 190 {}
N -830 200 -460 200 {}
N 1080 200 1140 200 {}
N -590 230 -530 230 {}
N -210 230 -150 230 {}
N 1965 230 2025 230 {}
N -1610 260 -1550 260 {}
N -930 260 -870 260 {}
N -830 260 -770 260 {}
N -590 260 -530 260 {}
N -490 260 -460 260 {}
N -250 260 -190 260 {}
N -150 260 -90 260 {}
N 295 260 355 260 {}
N 535 260 595 260 {}
N 635 260 695 260 {}
N 750 260 810 260 {}
N 870 260 900 260 {}
N 980 260 1040 260 {}
N 1080 260 1140 260 {}
N 1175 260 1265 260 {}
N 1305 260 1365 260 {}
N 1420 260 1480 260 {}
N 1520 260 1580 260 {}
N 1640 260 1700 260 {}
N 1760 260 1790 260 {}
N 1865 260 1925 260 {}
N 1965 260 2025 260 {}
N 2060 260 2150 260 {}
N 2190 260 2250 260 {}
N 1305 320 1520 320 {}
N 1965 320 2190 320 {}
N -930 520 -870 520 {}
N -830 520 -800 520 {}
N -590 520 -530 520 {}
N -490 520 1480 520 {}
N 1520 520 1580 520 {}
N 1895 520 1925 520 {}
N 1965 520 2025 520 {}
N -800 580 -460 580 {}
N 1450 580 1895 580 {}
N -2030 660 2645 660 {}
C {devices/lab_wire.sym} -530 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 1305 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -770 260 0 1 {name=l2 lab=VB3}
C {devices/lab_wire.sym} 295 170 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} 295 90 2 0 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 1420 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 1865 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} -870 90 2 0 {name=l7 lab=VB4}
C {devices/lab_wire.sym} -870 170 0 1 {name=l8 lab=VB4}
C {devices/lab_wire.sym} 980 260 0 0 {name=l9 lab=VB4}
C {devices/lab_wire.sym} -150 90 2 0 {name=l10 lab=VOUT}
C {devices/lab_wire.sym} 750 260 0 0 {name=l11 lab=VOUT}
C {devices/lab_wire.sym} 1420 0 0 0 {name=l12 lab=VOUTN}
C {devices/lab_wire.sym} 1520 170 0 1 {name=l13 lab=VOUTN}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l14 lab=net043}
C {devices/lab_wire.sym} 535 260 0 0 {name=l15 lab=net043}
C {devices/lab_wire.sym} -250 260 0 0 {name=l16 lab=net049}
C {devices/lab_wire.sym} 635 90 2 0 {name=l17 lab=net049}
C {devices/lab_wire.sym} 635 170 0 1 {name=l18 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l19 lab=net050}
C {devices/lab_wire.sym} -250 0 0 0 {name=l20 lab=net050}
C {devices/lab_wire.sym} 1040 -60 0 1 {name=l21 lab=net050}
C {devices/lab_wire.sym} 1760 320 2 0 {name=l22 lab=net050}
C {devices/lab_wire.sym} 1965 90 2 0 {name=l23 lab=net050}
C {devices/lab_wire.sym} 1965 350 2 0 {name=l24 lab=net063}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l25 lab=net1}
C {devices/lab_wire.sym} -770 0 0 1 {name=l26 lab=net1}
C {devices/lab_wire.sym} -25 0 0 0 {name=l27 lab=net1}
C {devices/lab_wire.sym} 195 0 0 0 {name=l28 lab=net1}
C {devices/lab_wire.sym} 535 0 0 0 {name=l29 lab=net1}
C {devices/lab_wire.sym} 1080 90 2 0 {name=l30 lab=net2}
C {devices/lab_wire.sym} 1640 260 0 0 {name=l31 lab=net2}
C {devices/lab_wire.sym} 75 90 2 0 {name=l32 lab=net31}
C {devices/lab_wire.sym} 1305 170 0 1 {name=l33 lab=net31}
C {devices/lab_wire.sym} 2190 170 0 1 {name=l34 lab=net31}
C {devices/lab_wire.sym} -870 350 2 0 {name=l35 lab=net54}
C {devices/lab_wire.sym} -530 350 2 0 {name=l36 lab=net56}
C {devices/lab_wire.sym} 1365 354 2 0 {name=l37 lab=net31}
C {devices/lab_wire.sym} 2250 354 2 0 {name=l38 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 1080 0 0 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} -90 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -530 0 0 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 355 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 135 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 1580 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 1965 0 0 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} 695 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} -930 354 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} -590 354 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} 355 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} 1580 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} 2025 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} -930 614 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} -590 614 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} 1580 614 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} 2025 614 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 1140 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} 695 354 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} -90 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l63 lab=net1}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l64 lab=vss}
C {devices/ipin.sym} 1175 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2060 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
