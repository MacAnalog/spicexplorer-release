v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_013_qu2017_azc} -2295 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 20 390 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} -850 520 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/capa_np.sym} 2390 520 0 0 {name=C2 value='CAPACITOR_2'}
C {devices/isource_np.sym} -2255 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} -690 390 1 0 {name=R0 value='RESISTOR_0'}
C {devices/res_np.sym} -935 390 1 0 {name=R1 value='RESISTOR_1'}
C {devices/res_np.sym} 805 260 1 0 {name=R2 value='RESISTOR_2'}
C {devices/res_np.sym} 2645 260 1 0 {name=R3 value='RESISTOR_3'}
C {devices/sg13_lv_pmos_np.sym} -490 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -150 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1685 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 2050 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M13 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 1015 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1460 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1870 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -150 260 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 20 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1015 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1460 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 2390 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 580 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_pmos_np.sym} 240 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 1015 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1460 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 2050 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 2390 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 580 0 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1240 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -2255 430 -2255 490 {}
N -2255 550 -2255 610 {}
N -1950 520 -1950 614 {}
N -1890 430 -1890 490 {}
N -1890 550 -1890 660 {}
N -1610 390 -1610 490 {}
N -1610 520 -1610 614 {}
N -1550 550 -1550 660 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 230 {}
N -1210 290 -1210 660 {}
N -1020 260 -1020 490 {}
N -905 390 -905 450 {}
N -890 60 -890 230 {}
N -875 330 -875 390 {}
N -850 550 -850 660 {}
N -830 -140 -830 -30 {}
N -830 30 -830 90 {}
N -830 290 -830 660 {}
N -770 0 -770 94 {}
N -770 260 -770 354 {}
N -630 330 -630 390 {}
N -570 0 -570 94 {}
N -510 -140 -510 -30 {}
N -510 30 -510 70 {}
N -470 0 -470 70 {}
N -230 30 -230 230 {}
N -230 260 -230 354 {}
N -170 -140 -170 -30 {}
N -170 30 -170 90 {}
N -170 190 -170 230 {}
N -170 290 -170 660 {}
N -130 0 -130 60 {}
N -130 190 -130 580 {}
N -30 -60 -30 0 {}
N 20 200 20 390 {}
N 40 -140 40 -30 {}
N 40 30 40 90 {}
N 80 390 80 520 {}
N 100 0 100 94 {}
N 190 -60 190 0 {}
N 260 -140 260 -30 {}
N 260 30 260 90 {}
N 320 0 320 94 {}
N 530 200 530 260 {}
N 600 -140 600 -30 {}
N 600 30 600 90 {}
N 600 170 600 230 {}
N 600 290 600 660 {}
N 660 0 660 94 {}
N 660 260 660 354 {}
N 865 200 865 260 {}
N 965 520 965 580 {}
N 995 0 995 70 {}
N 1035 -140 1035 -30 {}
N 1035 30 1035 70 {}
N 1035 290 1035 490 {}
N 1035 550 1035 660 {}
N 1095 30 1095 230 {}
N 1095 260 1095 354 {}
N 1095 520 1095 614 {}
N 1260 170 1260 230 {}
N 1260 290 1260 320 {}
N 1320 260 1320 354 {}
N 1410 520 1410 580 {}
N 1440 -60 1440 0 {}
N 1480 -140 1480 -30 {}
N 1480 30 1480 90 {}
N 1480 170 1480 230 {}
N 1480 290 1480 490 {}
N 1480 550 1480 660 {}
N 1540 0 1540 94 {}
N 1540 260 1540 354 {}
N 1540 520 1540 614 {}
N 1705 170 1705 230 {}
N 1705 290 1705 320 {}
N 1765 260 1765 354 {}
N 1970 0 1970 94 {}
N 1970 260 1970 354 {}
N 2030 -140 2030 -30 {}
N 2030 30 2030 70 {}
N 2030 170 2030 230 {}
N 2030 290 2030 660 {}
N 2070 0 2070 70 {}
N 2340 0 2340 60 {}
N 2340 260 2340 320 {}
N 2390 260 2390 490 {}
N 2390 550 2390 660 {}
N 2410 -140 2410 -30 {}
N 2410 30 2410 230 {}
N 2410 290 2410 660 {}
N 2470 0 2470 94 {}
N 2470 260 2470 354 {}
N 2585 260 2585 320 {}
N 2765 200 2765 260 {}
N -2370 -140 2920 -140 {}
N -30 -60 190 -60 {}
N -1270 0 -1210 0 {}
N -1170 0 -870 0 {}
N -830 0 -770 0 {}
N -570 0 -510 0 {}
N -470 0 -410 0 {}
N -130 0 0 0 {}
N 40 0 100 0 {}
N 190 0 220 0 {}
N 260 0 320 0 {}
N 500 0 560 0 {}
N 600 0 660 0 {}
N 935 0 995 0 {}
N 1410 0 1440 0 {}
N 1480 0 1540 0 {}
N 1970 0 2030 0 {}
N 2070 0 2130 0 {}
N 2340 0 2370 0 {}
N 2410 0 2470 0 {}
N -230 30 -170 30 {}
N 1035 30 1095 30 {}
N -890 60 -830 60 {}
N 2030 60 2340 60 {}
N -510 70 -470 70 {}
N 995 70 1035 70 {}
N 2030 70 2070 70 {}
N -170 190 -130 190 {}
N -1210 200 20 200 {}
N 530 200 865 200 {}
N 2410 200 2765 200 {}
N -890 230 -830 230 {}
N -230 230 -170 230 {}
N 1035 230 1095 230 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -1020 260 -870 260 {}
N -830 260 -770 260 {}
N -230 260 -170 260 {}
N 500 260 560 260 {}
N 600 260 660 260 {}
N 715 260 775 260 {}
N 835 260 865 260 {}
N 935 260 995 260 {}
N 1035 260 1095 260 {}
N 1130 260 1220 260 {}
N 1260 260 1320 260 {}
N 1380 260 1440 260 {}
N 1480 260 1540 260 {}
N 1575 260 1665 260 {}
N 1705 260 1765 260 {}
N 1970 260 2030 260 {}
N 2070 260 2130 260 {}
N 2310 260 2390 260 {}
N 2410 260 2470 260 {}
N 2585 260 2615 260 {}
N 2675 260 2765 260 {}
N 1035 320 1260 320 {}
N 1480 320 1705 320 {}
N 2340 320 2585 320 {}
N -875 330 -630 330 {}
N -1610 390 -965 390 {}
N -905 390 -875 390 {}
N -780 390 -720 390 {}
N -660 390 -630 390 {}
N -40 390 20 390 {}
N 50 390 1480 390 {}
N -1610 490 -1550 490 {}
N -1020 490 -850 490 {}
N -1950 520 -1890 520 {}
N -1850 520 -1790 520 {}
N -1610 520 -1550 520 {}
N -1510 520 80 520 {}
N 965 520 995 520 {}
N 1035 520 1095 520 {}
N 1410 520 1440 520 {}
N 1480 520 1540 520 {}
N -130 580 1410 580 {}
N -2370 660 2920 660 {}
C {devices/lab_wire.sym} -1790 520 0 1 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} 1035 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -410 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} -130 60 2 0 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 500 0 0 0 {name=l4 lab=VB1}
C {devices/lab_wire.sym} -170 90 2 0 {name=l5 lab=VB4}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l6 lab=VOUT}
C {devices/lab_wire.sym} 935 0 0 0 {name=l7 lab=VOUTN}
C {devices/lab_wire.sym} 1440 -60 0 1 {name=l8 lab=VOUTN}
C {devices/lab_wire.sym} 40 90 2 0 {name=l9 lab=net019}
C {devices/lab_wire.sym} 1260 170 0 1 {name=l10 lab=net019}
C {devices/lab_wire.sym} 1705 170 0 1 {name=l11 lab=net019}
C {devices/lab_wire.sym} 2310 260 0 0 {name=l12 lab=net043}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l13 lab=net049}
C {devices/lab_wire.sym} 600 90 2 0 {name=l14 lab=net049}
C {devices/lab_wire.sym} 600 170 0 1 {name=l15 lab=net049}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l16 lab=net050}
C {devices/lab_wire.sym} 1480 90 2 0 {name=l17 lab=net050}
C {devices/lab_wire.sym} 1480 170 0 1 {name=l18 lab=net050}
C {devices/lab_wire.sym} -930 260 0 0 {name=l19 lab=net051}
C {devices/lab_wire.sym} 715 260 0 0 {name=l20 lab=net051}
C {devices/lab_wire.sym} 2130 0 0 1 {name=l21 lab=net055}
C {devices/lab_wire.sym} 2030 170 0 1 {name=l22 lab=net055}
C {devices/lab_wire.sym} 500 260 0 0 {name=l23 lab=net057}
C {devices/lab_wire.sym} 2410 90 2 0 {name=l24 lab=net057}
C {devices/lab_wire.sym} 1480 350 2 0 {name=l25 lab=net063}
C {devices/lab_wire.sym} -1890 430 0 1 {name=l26 lab=net077}
C {devices/lab_wire.sym} -780 390 0 0 {name=l27 lab=net077}
C {devices/lab_wire.sym} 935 260 0 0 {name=l28 lab=net077}
C {devices/lab_wire.sym} -905 450 2 0 {name=l29 lab=net078}
C {devices/lab_wire.sym} 260 90 2 0 {name=l30 lab=net078}
C {devices/lab_wire.sym} -1025 390 0 0 {name=l31 lab=net082}
C {devices/lab_wire.sym} 1380 260 0 0 {name=l32 lab=net082}
C {devices/lab_wire.sym} -830 90 2 0 {name=l33 lab=net094}
C {devices/lab_wire.sym} 2130 260 0 1 {name=l34 lab=net094}
C {devices/lab_wire.sym} 1765 354 2 0 {name=l35 lab=net019}
C {devices/lab_wire.sym} 1320 354 2 0 {name=l36 lab=net019}
C {devices/lab_wire.sym} -570 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} -170 0 0 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} -770 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 100 94 2 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} 320 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} 1035 0 0 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} 1540 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 1970 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 2470 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 660 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 1970 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 1095 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} 1540 354 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} -1950 614 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} -230 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} 1095 614 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} 1540 614 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} -770 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} 2470 354 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 660 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} -2255 610 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -2255 430 0 1 {name=l61 lab=VB1}
C {devices/ipin.sym} 1130 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 1575 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2370 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2370 660 0 0 {name=p3 lab=vss}
