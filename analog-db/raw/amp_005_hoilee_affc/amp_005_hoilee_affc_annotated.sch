v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_005_hoilee_affc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1700 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1080 390 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -480 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 1920 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 795 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -110 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 570 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -850 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -110 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 115 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 1475 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 1920 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 795 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 105 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -110 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1135 0 0 0 {name=M59 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm59_w l=x_dut_xm59_l m=x_dut_xm59_m}
C {devices/sg13_lv_pmos_np.sym} 340 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_nmos_np.sym} 1135 260 0 0 {name=M60 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm60_w l=x_dut_xm60_l m=x_dut_xm60_m}
C {devices/sg13_lv_nmos_np.sym} 1135 520 0 0 {name=M61 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 570 0 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 340 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 340 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 1475 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 105 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 90 {}
N -1210 170 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 660 {}
N -1170 200 -1170 260 {}
N -1140 520 -1140 580 {}
N -930 60 -930 230 {}
N -930 260 -930 354 {}
N -930 520 -930 614 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 290 -870 490 {}
N -870 550 -870 660 {}
N -800 200 -800 260 {}
N -800 520 -800 580 {}
N -590 0 -590 94 {}
N -530 -140 -530 -30 {}
N -530 30 -530 70 {}
N -490 0 -490 70 {}
N -460 170 -460 230 {}
N -460 290 -460 350 {}
N -400 260 -400 354 {}
N -190 0 -190 94 {}
N -190 260 -190 354 {}
N -190 520 -190 614 {}
N -130 -140 -130 -30 {}
N -130 30 -130 70 {}
N -130 170 -130 230 {}
N -130 290 -130 350 {}
N -130 430 -130 490 {}
N -130 550 -130 660 {}
N -90 0 -90 70 {}
N -60 520 -60 580 {}
N 25 30 25 230 {}
N 25 260 25 354 {}
N 65 520 65 580 {}
N 85 -140 85 -30 {}
N 85 30 85 90 {}
N 85 290 85 350 {}
N 135 460 135 490 {}
N 135 550 135 660 {}
N 195 320 195 460 {}
N 195 520 195 614 {}
N 290 200 290 260 {}
N 290 520 290 580 {}
N 300 60 300 230 {}
N 300 290 300 460 {}
N 360 -140 360 -30 {}
N 360 30 360 60 {}
N 360 60 360 90 {}
N 360 290 360 350 {}
N 360 460 360 490 {}
N 360 550 360 660 {}
N 420 0 420 94 {}
N 420 260 420 354 {}
N 420 520 420 614 {}
N 520 200 520 260 {}
N 590 -140 590 -30 {}
N 590 30 590 60 {}
N 590 290 590 350 {}
N 650 0 650 94 {}
N 650 260 650 354 {}
N 775 190 775 260 {}
N 815 -140 815 -30 {}
N 815 30 815 90 {}
N 815 170 815 230 {}
N 815 290 815 660 {}
N 875 0 875 94 {}
N 875 260 875 354 {}
N 1115 0 1115 70 {}
N 1155 -140 1155 -30 {}
N 1155 30 1155 70 {}
N 1155 170 1155 230 {}
N 1155 290 1155 490 {}
N 1155 550 1155 660 {}
N 1215 0 1215 94 {}
N 1215 260 1215 354 {}
N 1215 520 1215 614 {}
N 1495 -140 1495 -30 {}
N 1495 30 1495 230 {}
N 1495 290 1495 660 {}
N 1555 0 1555 94 {}
N 1555 260 1555 354 {}
N 1700 200 1700 230 {}
N 1700 290 1700 390 {}
N 1870 200 1870 260 {}
N 1900 -60 1900 0 {}
N 1940 -140 1940 -30 {}
N 1940 30 1940 230 {}
N 1940 290 1940 660 {}
N 2000 0 2000 94 {}
N 2000 200 2000 320 {}
N -2030 -140 2420 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -490 0 -430 0 {}
N -190 0 -130 0 {}
N -90 0 -30 0 {}
N 125 0 185 0 {}
N 260 0 320 0 {}
N 360 0 420 0 {}
N 490 0 550 0 {}
N 590 0 650 0 {}
N 715 0 775 0 {}
N 815 0 875 0 {}
N 1055 0 1115 0 {}
N 1155 0 1215 0 {}
N 1395 0 1455 0 {}
N 1495 0 1555 0 {}
N 1870 0 1900 0 {}
N 1940 0 2000 0 {}
N 25 30 85 30 {}
N -930 60 -870 60 {}
N 300 60 590 60 {}
N -530 70 -490 70 {}
N -130 70 -90 70 {}
N 1115 70 1155 70 {}
N -1550 190 -1510 190 {}
N 775 190 815 190 {}
N -1170 200 -800 200 {}
N 290 200 520 200 {}
N 1495 200 1870 200 {}
N 1940 200 2000 200 {}
N -930 230 -870 230 {}
N 25 230 85 230 {}
N 300 230 590 230 {}
N -1610 260 -1550 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -930 260 -870 260 {}
N -830 260 -800 260 {}
N -590 260 -500 260 {}
N -460 260 -400 260 {}
N -190 260 -130 260 {}
N -90 260 -30 260 {}
N 25 260 85 260 {}
N 125 260 155 260 {}
N 260 260 320 260 {}
N 360 260 420 260 {}
N 520 260 550 260 {}
N 590 260 650 260 {}
N 815 260 875 260 {}
N 1055 260 1115 260 {}
N 1155 260 1215 260 {}
N 1395 260 1455 260 {}
N 1495 260 1555 260 {}
N 1870 260 1900 260 {}
N 300 290 360 290 {}
N -460 320 195 320 {}
N 1700 320 2000 320 {}
N 300 390 1050 390 {}
N 1110 390 1700 390 {}
N 135 460 195 460 {}
N 300 460 360 460 {}
N -1270 520 -1210 520 {}
N -1170 520 -1110 520 {}
N -930 520 -870 520 {}
N -830 520 -800 520 {}
N -190 520 -130 520 {}
N -90 520 95 520 {}
N 135 520 195 520 {}
N 290 520 320 520 {}
N 360 520 420 520 {}
N 1055 520 1115 520 {}
N 1155 520 1215 520 {}
N -1140 580 -60 580 {}
N 65 580 290 580 {}
N -2030 660 2420 660 {}
C {devices/lab_wire.sym} -870 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -130 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -130 430 0 1 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} 85 350 2 0 {name=l3 lab=DM_2}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} -30 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 260 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 815 170 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 815 90 2 0 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 1055 260 0 0 {name=l9 lab=VB3}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l10 lab=VB4}
C {devices/lab_wire.sym} -1210 170 0 1 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -1110 520 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} 1055 520 0 0 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 1940 90 2 0 {name=l14 lab=VOUT}
C {devices/lab_wire.sym} -30 0 0 1 {name=l15 lab=VOUTN}
C {devices/lab_wire.sym} -130 170 0 1 {name=l16 lab=VOUTN}
C {devices/lab_wire.sym} 260 0 0 0 {name=l17 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l18 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l19 lab=net013}
C {devices/lab_wire.sym} -430 0 0 1 {name=l20 lab=net013}
C {devices/lab_wire.sym} 185 0 0 1 {name=l21 lab=net013}
C {devices/lab_wire.sym} 715 0 0 0 {name=l22 lab=net013}
C {devices/lab_wire.sym} 1395 0 0 0 {name=l23 lab=net013}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l24 lab=net043}
C {devices/lab_wire.sym} 1395 260 0 0 {name=l25 lab=net043}
C {devices/lab_wire.sym} 1495 90 2 0 {name=l26 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l27 lab=net050}
C {devices/lab_wire.sym} 360 90 2 0 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1900 -60 0 1 {name=l29 lab=net050}
C {devices/lab_wire.sym} -460 350 2 0 {name=l30 lab=net063}
C {devices/lab_wire.sym} 590 350 2 0 {name=l31 lab=net063}
C {devices/lab_wire.sym} 360 350 2 0 {name=l32 lab=net1}
C {devices/lab_wire.sym} 490 0 0 0 {name=l33 lab=net2}
C {devices/lab_wire.sym} 1055 0 0 0 {name=l34 lab=net2}
C {devices/lab_wire.sym} 1155 170 0 1 {name=l35 lab=net2}
C {devices/lab_wire.sym} 1155 350 2 0 {name=l36 lab=net3}
C {devices/lab_wire.sym} -460 170 0 1 {name=l37 lab=net31}
C {devices/lab_wire.sym} 85 90 2 0 {name=l38 lab=net31}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l39 lab=net54}
C {devices/lab_wire.sym} -870 350 2 0 {name=l40 lab=net56}
C {devices/lab_wire.sym} -400 354 2 0 {name=l41 lab=net31}
C {devices/lab_wire.sym} 25 354 2 0 {name=l42 lab=net31}
C {devices/lab_wire.sym} -590 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 2000 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} -870 0 0 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 875 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} 85 0 0 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} -190 94 2 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} 1215 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} 420 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} 650 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} 1555 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} 875 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} -190 354 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} 650 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -930 614 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} -190 614 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} 195 614 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} 1555 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} 1940 260 0 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} 1215 354 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} 1215 614 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} 420 354 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 420 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l71 lab=net013}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l72 lab=vss}
C {devices/ipin.sym} -590 260 0 0 {name=p0 lab=VINP}
C {devices/ipin.sym} 155 260 0 0 {name=p1 lab=VINN}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
B 8 -1646 -78 1931 78 {fill=0}
T {PMOS Simple Current Mirror (5 outputs)} -1646 -96 0 0 0.3 0.3 {layer=8}
B 10 -1670 182 1615 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror (2 outputs) [alt: cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode]} -1670 164 0 0 0.3 0.3 {layer=10}
B 12 -2010 182 1955 338 {fill=0}
T {NMOS Simple Current Mirror} -2010 164 0 0 0.3 0.3 {layer=12}
B 21 -566 -78 796 78 {fill=0}
T {PMOS Simple Current Mirror} -566 -96 0 0 0.3 0.3 {layer=21}
B 15 500 -78 1615 78 {fill=0}
T {PMOS Simple Current Mirror} 500 -96 0 0 0.3 0.3 {layer=15}
B 13 -550 182 175 338 {fill=0}
T {PMOS Differential Pair} -550 164 0 0 0.3 0.3 {layer=13}
