v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_011_peng_iac} -2200 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -1820 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1065 520 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -2160 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 1225 780 0 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} 995 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} 220 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -675 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1460 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 220 520 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 655 520 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 1335 520 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1120 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -225 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 220 780 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 655 780 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1120 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 655 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -225 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1460 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 1335 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 440 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1120 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 995 260 0 1 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} 220 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} -225 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 655 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 1335 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 1675 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 1675 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 1675 0 0 0 {name=M65 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 2015 260 0 0 {name=M66 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm66_w l=x_dut_xm66_l m=x_dut_xm66_m}
C {devices/sg13_lv_nmos_np.sym} -675 260 0 1 {name=M67 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm67_w l=x_dut_xm67_l m=x_dut_xm67_m}
C {devices/sg13_lv_nmos_np.sym} -675 520 0 1 {name=M68 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_nmos_np.sym} 2015 520 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 2015 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} -450 520 0 1 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_pmos_np.sym} -900 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} -5 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -2160 690 -2160 750 {}
N -2160 810 -2160 870 {}
N -1940 200 -1940 260 {}
N -1790 260 -1790 320 {}
N -1540 0 -1540 94 {}
N -1540 260 -1540 354 {}
N -1480 -140 -1480 -30 {}
N -1480 30 -1480 230 {}
N -1480 290 -1480 920 {}
N -1200 0 -1200 94 {}
N -1200 260 -1200 354 {}
N -1200 520 -1200 614 {}
N -1140 -140 -1140 -30 {}
N -1140 30 -1140 230 {}
N -1140 290 -1140 490 {}
N -1140 550 -1140 920 {}
N -1100 0 -1100 70 {}
N -980 260 -980 354 {}
N -920 200 -920 230 {}
N -920 290 -920 320 {}
N -755 30 -755 230 {}
N -755 260 -755 354 {}
N -755 520 -755 614 {}
N -695 -140 -695 -30 {}
N -695 30 -695 90 {}
N -695 290 -695 490 {}
N -695 550 -695 920 {}
N -685 0 -685 30 {}
N -655 0 -655 60 {}
N -530 520 -530 614 {}
N -470 460 -470 490 {}
N -470 550 -470 920 {}
N -305 0 -305 94 {}
N -305 260 -305 354 {}
N -305 520 -305 614 {}
N -245 -140 -245 -30 {}
N -245 170 -245 230 {}
N -245 290 -245 490 {}
N -245 550 -245 920 {}
N -235 460 -235 520 {}
N -205 0 -205 60 {}
N -85 260 -85 354 {}
N -25 200 -25 230 {}
N -25 290 -25 320 {}
N 140 60 140 230 {}
N 140 260 140 354 {}
N 140 520 140 614 {}
N 140 780 140 874 {}
N 200 -140 200 -30 {}
N 200 30 200 90 {}
N 200 290 200 490 {}
N 200 550 200 750 {}
N 200 810 200 920 {}
N 240 400 240 520 {}
N 270 780 270 840 {}
N 360 0 360 94 {}
N 420 -140 420 -30 {}
N 420 30 420 90 {}
N 480 60 480 200 {}
N 575 0 575 94 {}
N 575 260 575 354 {}
N 575 520 575 614 {}
N 575 780 575 874 {}
N 635 -140 635 -30 {}
N 635 30 635 230 {}
N 635 290 635 490 {}
N 635 550 635 750 {}
N 635 810 635 920 {}
N 705 140 705 260 {}
N 705 400 705 520 {}
N 705 780 705 840 {}
N 915 0 915 94 {}
N 915 260 915 354 {}
N 945 520 945 720 {}
N 975 -140 975 -30 {}
N 975 30 975 230 {}
N 975 290 975 320 {}
N 1045 140 1045 260 {}
N 1105 0 1105 320 {}
N 1125 400 1125 520 {}
N 1225 720 1225 750 {}
N 1225 810 1225 920 {}
N 1285 140 1285 260 {}
N 1315 450 1315 520 {}
N 1355 -140 1355 -30 {}
N 1355 30 1355 230 {}
N 1355 290 1355 490 {}
N 1355 550 1355 920 {}
N 1415 0 1415 94 {}
N 1415 260 1415 354 {}
N 1415 520 1415 614 {}
N 1655 0 1655 70 {}
N 1685 260 1685 320 {}
N 1695 -140 1695 -30 {}
N 1695 30 1695 230 {}
N 1695 290 1695 490 {}
N 1695 550 1695 920 {}
N 1755 0 1755 94 {}
N 1755 260 1755 354 {}
N 1755 520 1755 614 {}
N 2025 200 2025 260 {}
N 2035 -140 2035 -30 {}
N 2035 30 2035 230 {}
N 2035 290 2035 490 {}
N 2035 550 2035 920 {}
N 2095 0 2095 94 {}
N 2095 260 2095 354 {}
N 2095 520 2095 614 {}
N -2220 -140 2515 -140 {}
N -1540 0 -1480 0 {}
N -1440 0 -1380 0 {}
N -1200 0 -1140 0 {}
N -1100 0 -1040 0 {}
N -685 0 -625 0 {}
N -305 0 -245 0 {}
N -205 0 -175 0 {}
N 240 0 300 0 {}
N 360 0 420 0 {}
N 460 0 520 0 {}
N 575 0 635 0 {}
N 675 0 735 0 {}
N 915 0 975 0 {}
N 1015 0 1315 0 {}
N 1355 0 1415 0 {}
N 1595 0 1655 0 {}
N 1695 0 1755 0 {}
N 1935 0 1995 0 {}
N 2035 0 2095 0 {}
N -755 30 -695 30 {}
N -685 30 -245 30 {}
N 140 60 200 60 {}
N 420 60 480 60 {}
N -1140 70 -1100 70 {}
N 1655 70 1695 70 {}
N 705 140 1045 140 {}
N 1285 140 1695 140 {}
N -1940 200 -1480 200 {}
N -980 200 480 200 {}
N 1695 200 2025 200 {}
N -755 230 -695 230 {}
N 140 230 200 230 {}
N -1940 260 -1850 260 {}
N -1790 260 -1760 260 {}
N -1540 260 -1480 260 {}
N -1440 260 -1380 260 {}
N -1200 260 -1140 260 {}
N -1100 260 -1040 260 {}
N -980 260 -920 260 {}
N -880 260 -850 260 {}
N -755 260 -695 260 {}
N -655 260 -595 260 {}
N -305 260 -245 260 {}
N -205 260 -145 260 {}
N -85 260 -25 260 {}
N 15 260 45 260 {}
N 140 260 200 260 {}
N 240 260 300 260 {}
N 575 260 635 260 {}
N 675 260 705 260 {}
N 915 260 975 260 {}
N 1015 260 1315 260 {}
N 1355 260 1415 260 {}
N 1595 260 1685 260 {}
N 1695 260 1755 260 {}
N 1965 260 2025 260 {}
N 2035 260 2095 260 {}
N -1140 320 -920 320 {}
N -245 320 -25 320 {}
N 975 320 1105 320 {}
N 1355 320 1685 320 {}
N 240 400 705 400 {}
N 1125 400 2035 400 {}
N 1315 450 1355 450 {}
N -695 460 -470 460 {}
N -235 460 200 460 {}
N 705 460 1315 460 {}
N -1200 520 -1140 520 {}
N -1100 520 -1040 520 {}
N -755 520 -695 520 {}
N -655 520 -595 520 {}
N -530 520 -470 520 {}
N -430 520 -370 520 {}
N -305 520 -245 520 {}
N -235 520 -175 520 {}
N 140 520 200 520 {}
N 575 520 635 520 {}
N 675 520 705 520 {}
N 945 520 1035 520 {}
N 1095 520 1125 520 {}
N 1355 520 1415 520 {}
N 1595 520 1655 520 {}
N 1695 520 1755 520 {}
N 1935 520 1995 520 {}
N 2035 520 2095 520 {}
N 945 720 1225 720 {}
N 140 780 200 780 {}
N 240 780 300 780 {}
N 575 780 635 780 {}
N 675 780 705 780 {}
N 270 840 705 840 {}
N -2220 920 2515 920 {}
C {devices/lab_wire.sym} -1140 350 2 0 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} 300 0 0 1 {name=l1 lab=VB1}
C {devices/lab_wire.sym} 520 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} 735 0 0 1 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 1075 0 0 1 {name=l4 lab=VB1}
C {devices/lab_wire.sym} 1935 0 0 0 {name=l5 lab=VB1}
C {devices/lab_wire.sym} 300 260 0 1 {name=l6 lab=VB2}
C {devices/lab_wire.sym} 1595 0 0 0 {name=l7 lab=VB2}
C {devices/lab_wire.sym} -1040 260 0 1 {name=l8 lab=VB3}
C {devices/lab_wire.sym} -595 260 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} -145 260 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} 1595 260 0 0 {name=l11 lab=VB3}
C {devices/lab_wire.sym} -1040 520 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -595 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 200 350 2 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 300 780 0 1 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1595 520 0 0 {name=l16 lab=VB4}
C {devices/lab_wire.sym} -1480 90 2 0 {name=l17 lab=VOUT}
C {devices/lab_wire.sym} -1040 0 0 1 {name=l18 lab=VOUTN}
C {devices/lab_wire.sym} -205 60 2 0 {name=l19 lab=VOUTN}
C {devices/lab_wire.sym} -1790 320 2 0 {name=l20 lab=VOUTP}
C {devices/lab_wire.sym} -1380 0 0 1 {name=l21 lab=VOUTP}
C {devices/lab_wire.sym} -655 60 2 0 {name=l22 lab=VOUTP}
C {devices/lab_wire.sym} -245 170 0 1 {name=l23 lab=VOUTP}
C {devices/lab_wire.sym} -695 90 2 0 {name=l24 lab=net043}
C {devices/lab_wire.sym} -370 520 0 1 {name=l25 lab=net043}
C {devices/lab_wire.sym} 1935 520 0 0 {name=l26 lab=net043}
C {devices/lab_wire.sym} 2035 90 2 0 {name=l27 lab=net049}
C {devices/lab_wire.sym} -245 350 2 0 {name=l28 lab=net063}
C {devices/lab_wire.sym} -695 350 2 0 {name=l29 lab=net1}
C {devices/lab_wire.sym} -1380 260 0 1 {name=l30 lab=net10}
C {devices/lab_wire.sym} 2035 350 2 0 {name=l31 lab=net10}
C {devices/lab_wire.sym} 975 90 2 0 {name=l32 lab=net2}
C {devices/lab_wire.sym} 200 90 2 0 {name=l33 lab=net3}
C {devices/lab_wire.sym} 420 90 2 0 {name=l34 lab=net31}
C {devices/lab_wire.sym} 975 520 0 0 {name=l35 lab=net4}
C {devices/lab_wire.sym} 200 610 2 0 {name=l36 lab=net54}
C {devices/lab_wire.sym} 635 610 2 0 {name=l37 lab=net56}
C {devices/lab_wire.sym} 635 90 2 0 {name=l38 lab=net6}
C {devices/lab_wire.sym} 635 350 2 0 {name=l39 lab=net7}
C {devices/lab_wire.sym} 1355 90 2 0 {name=l40 lab=net8}
C {devices/lab_wire.sym} 1695 350 2 0 {name=l41 lab=net9}
C {devices/lab_wire.sym} -980 354 2 0 {name=l42 lab=net31}
C {devices/lab_wire.sym} -85 354 2 0 {name=l43 lab=net31}
C {devices/lab_wire.sym} 915 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 200 0 0 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} -695 0 0 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} -1540 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 575 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} 1415 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} 360 94 2 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} -1200 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} 915 354 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} 140 354 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -305 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} 575 354 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} 1415 354 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 1755 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 2095 354 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 2095 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 140 614 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} 575 614 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} 1415 614 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -1200 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} -305 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} 140 874 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} 575 874 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} -1200 614 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} -305 614 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} -1540 354 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 1755 354 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 1755 614 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} -755 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} -755 614 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} 2095 614 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} -530 614 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} -2160 690 0 1 {name=l76 lab=VB1}
C {devices/lab_wire.sym} -2160 870 2 0 {name=l77 lab=vss}
C {devices/ipin.sym} -850 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 45 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2220 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2220 920 0 0 {name=p3 lab=vss}
B 8 -260 182 2155 858 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror (2 outputs) [alt: cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode]} -260 164 0 0 0.3 0.3 {layer=8}
B 10 -1576 -78 -155 78 {fill=0}
T {PMOS Simple Current Mirror} -1576 -96 0 0 0.3 0.3 {layer=10}
B 12 -260 -78 2495 338 {fill=0}
T {PMOS Improved High Swing Cascode Current Mirror (4 outputs) [alt: cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode]} -260 -96 0 0 0.3 0.3 {layer=12}
B 21 -1356 182 65 338 {fill=0}
T {PMOS Differential Pair} -1356 164 0 0 0.3 0.3 {layer=21}
