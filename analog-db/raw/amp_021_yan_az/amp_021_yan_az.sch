v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_021_yan_az} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1035 390 1 0 {name=C0 value='CAPACITOR_1'}
C {devices/capa_np.sym} 800 520 0 0 {name=C1 value='CAPACITOR_0'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_1_BIAS'}
C {devices/res_np.sym} -850 390 1 0 {name=R0 value='RESISTOR_1'}
C {devices/res_np.sym} -640 390 1 0 {name=R1 value='RESISTOR_2'}
C {devices/res_np.sym} 1025 260 0 0 {name=R2 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -460 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1905 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 800 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 460 0 0 1 {name=M13 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 1235 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1680 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 460 260 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -460 260 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 100 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1235 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1680 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 800 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 2130 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} -120 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 1235 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1680 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 2130 0 0 0 {name=M67 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm67_w l=x_dut_xm67_l m=x_dut_xm67_m}
C {devices/sg13_lv_pmos_np.sym} 1460 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 390 -1610 460 {}
N -1610 520 -1610 614 {}
N -1550 460 -1550 490 {}
N -1550 550 -1550 660 {}
N -1270 520 -1270 614 {}
N -1210 430 -1210 490 {}
N -1210 550 -1210 660 {}
N -930 0 -930 94 {}
N -870 -140 -870 -30 {}
N -870 30 -870 70 {}
N -830 -60 -830 70 {}
N -790 330 -790 390 {}
N -580 330 -580 390 {}
N -540 30 -540 200 {}
N -540 260 -540 354 {}
N -480 -140 -480 -30 {}
N -480 30 -480 90 {}
N -480 190 -480 230 {}
N -480 290 -480 660 {}
N -440 190 -440 260 {}
N -410 -60 -410 0 {}
N -100 -140 -100 -30 {}
N -100 30 -100 390 {}
N -40 0 -40 94 {}
N 120 -140 120 -30 {}
N 120 30 120 90 {}
N 180 0 180 94 {}
N 380 0 380 94 {}
N 380 230 380 390 {}
N 440 -140 440 -30 {}
N 440 30 440 90 {}
N 440 170 440 230 {}
N 440 290 440 660 {}
N 450 200 450 260 {}
N 690 0 690 60 {}
N 760 30 760 230 {}
N 800 260 800 490 {}
N 800 550 800 660 {}
N 820 -140 820 -30 {}
N 820 30 820 90 {}
N 820 290 820 660 {}
N 880 0 880 94 {}
N 880 260 880 354 {}
N 1025 290 1025 460 {}
N 1095 390 1095 520 {}
N 1185 520 1185 580 {}
N 1215 0 1215 70 {}
N 1255 -140 1255 -30 {}
N 1255 30 1255 70 {}
N 1255 290 1255 490 {}
N 1255 550 1255 660 {}
N 1315 30 1315 230 {}
N 1315 260 1315 354 {}
N 1315 520 1315 614 {}
N 1480 170 1480 230 {}
N 1480 290 1480 320 {}
N 1540 260 1540 354 {}
N 1630 520 1630 580 {}
N 1660 -60 1660 0 {}
N 1700 -140 1700 -30 {}
N 1700 30 1700 60 {}
N 1700 170 1700 230 {}
N 1700 290 1700 490 {}
N 1700 550 1700 660 {}
N 1760 0 1760 94 {}
N 1760 260 1760 354 {}
N 1760 520 1760 614 {}
N 1925 170 1925 230 {}
N 1925 290 1925 320 {}
N 1985 260 1985 354 {}
N 2110 -60 2110 0 {}
N 2150 -140 2150 -30 {}
N 2150 30 2150 230 {}
N 2150 290 2150 660 {}
N 2210 0 2210 94 {}
N 2210 260 2210 354 {}
N -2030 -140 2630 -140 {}
N -830 -60 -410 -60 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -440 0 -140 0 {}
N -100 0 -40 0 {}
N 20 0 80 0 {}
N 120 0 180 0 {}
N 380 0 440 0 {}
N 480 0 780 0 {}
N 820 0 880 0 {}
N 1155 0 1215 0 {}
N 1630 0 1660 0 {}
N 1700 0 1760 0 {}
N 2080 0 2110 0 {}
N 2150 0 2210 0 {}
N -540 30 -480 30 {}
N 760 30 820 30 {}
N 1255 30 1315 30 {}
N 690 60 1700 60 {}
N -870 70 -830 70 {}
N 1215 70 1255 70 {}
N -480 190 -440 190 {}
N -540 200 -480 200 {}
N 450 200 2150 200 {}
N 380 230 440 230 {}
N 760 230 1025 230 {}
N 1255 230 1315 230 {}
N -540 260 -480 260 {}
N 450 260 510 260 {}
N 720 260 800 260 {}
N 820 260 880 260 {}
N 1155 260 1215 260 {}
N 1255 260 1315 260 {}
N 1350 260 1440 260 {}
N 1480 260 1540 260 {}
N 1600 260 1660 260 {}
N 1700 260 1760 260 {}
N 1795 260 1885 260 {}
N 1925 260 1985 260 {}
N 2050 260 2110 260 {}
N 2150 260 2210 260 {}
N 1255 320 1480 320 {}
N 1700 320 1925 320 {}
N -790 330 -580 330 {}
N -1610 390 -880 390 {}
N -820 390 -790 390 {}
N -730 390 -670 390 {}
N -610 390 -100 390 {}
N 380 390 1005 390 {}
N 1065 390 1700 390 {}
N -1610 460 -1550 460 {}
N 800 460 1025 460 {}
N -1610 520 -1550 520 {}
N -1510 520 -1450 520 {}
N -1270 520 -1210 520 {}
N -1170 520 1095 520 {}
N 1155 520 1215 520 {}
N 1255 520 1315 520 {}
N 1630 520 1660 520 {}
N 1700 520 1760 520 {}
N 1185 580 1630 580 {}
N -2030 660 2630 660 {}
C {devices/lab_wire.sym} -1450 520 0 1 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} 1255 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -770 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} 20 0 0 0 {name=l3 lab=VB1}
C {devices/lab_wire.sym} -480 90 2 0 {name=l4 lab=VB4}
C {devices/lab_wire.sym} 1155 520 0 0 {name=l5 lab=VB4}
C {devices/lab_wire.sym} 440 90 2 0 {name=l6 lab=VOUT}
C {devices/lab_wire.sym} 440 170 0 1 {name=l7 lab=VOUT}
C {devices/lab_wire.sym} 1155 0 0 0 {name=l8 lab=VOUTN}
C {devices/lab_wire.sym} 1660 -60 0 1 {name=l9 lab=VOUTN}
C {devices/lab_wire.sym} 2110 -60 0 1 {name=l10 lab=VOUTN}
C {devices/lab_wire.sym} 120 90 2 0 {name=l11 lab=net019}
C {devices/lab_wire.sym} 1480 170 0 1 {name=l12 lab=net019}
C {devices/lab_wire.sym} 1925 170 0 1 {name=l13 lab=net019}
C {devices/lab_wire.sym} 540 0 0 1 {name=l14 lab=net050}
C {devices/lab_wire.sym} 1700 170 0 1 {name=l15 lab=net050}
C {devices/lab_wire.sym} 720 260 0 0 {name=l16 lab=net051}
C {devices/lab_wire.sym} 2150 90 2 0 {name=l17 lab=net057}
C {devices/lab_wire.sym} 1700 350 2 0 {name=l18 lab=net063}
C {devices/lab_wire.sym} -940 390 0 0 {name=l19 lab=net077}
C {devices/lab_wire.sym} 1155 260 0 0 {name=l20 lab=net077}
C {devices/lab_wire.sym} -100 90 2 0 {name=l21 lab=net078}
C {devices/lab_wire.sym} -1210 430 0 1 {name=l22 lab=net082}
C {devices/lab_wire.sym} -730 390 0 0 {name=l23 lab=net082}
C {devices/lab_wire.sym} 1600 260 0 0 {name=l24 lab=net082}
C {devices/lab_wire.sym} 820 90 2 0 {name=l25 lab=net094}
C {devices/lab_wire.sym} 2050 260 0 0 {name=l26 lab=net094}
C {devices/lab_wire.sym} 1985 354 2 0 {name=l27 lab=net019}
C {devices/lab_wire.sym} 1540 354 2 0 {name=l28 lab=net019}
C {devices/lab_wire.sym} -930 94 2 0 {name=l29 lab=vdd}
C {devices/lab_wire.sym} -480 0 0 0 {name=l30 lab=vdd}
C {devices/lab_wire.sym} 880 94 2 0 {name=l31 lab=vdd}
C {devices/lab_wire.sym} 380 94 2 0 {name=l32 lab=vdd}
C {devices/lab_wire.sym} 180 94 2 0 {name=l33 lab=vdd}
C {devices/lab_wire.sym} -40 94 2 0 {name=l34 lab=vdd}
C {devices/lab_wire.sym} 1255 0 0 0 {name=l35 lab=vdd}
C {devices/lab_wire.sym} 1760 94 2 0 {name=l36 lab=vdd}
C {devices/lab_wire.sym} 2210 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} 1315 354 2 0 {name=l38 lab=vss}
C {devices/lab_wire.sym} 1760 354 2 0 {name=l39 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l40 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l41 lab=vss}
C {devices/lab_wire.sym} 440 260 0 0 {name=l42 lab=vss}
C {devices/lab_wire.sym} -540 354 2 0 {name=l43 lab=vss}
C {devices/lab_wire.sym} 1315 614 2 0 {name=l44 lab=vss}
C {devices/lab_wire.sym} 1760 614 2 0 {name=l45 lab=vss}
C {devices/lab_wire.sym} 880 354 2 0 {name=l46 lab=vss}
C {devices/lab_wire.sym} 2210 354 2 0 {name=l47 lab=vss}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l49 lab=VB1}
C {devices/ipin.sym} 1350 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 1795 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
