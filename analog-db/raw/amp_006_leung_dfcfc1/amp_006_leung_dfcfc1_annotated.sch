v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_006_leung_dfcfc1} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1740 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 170 260 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 2260 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 1960 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 390 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 10 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1070 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1515 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 390 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 390 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1070 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1515 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 730 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 1960 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} 10 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -340 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1070 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1515 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 730 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1295 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 90 {}
N -1210 170 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 660 {}
N -930 60 -930 230 {}
N -930 260 -930 354 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 660 {}
N -800 -60 -800 0 {}
N -800 200 -800 260 {}
N -590 0 -590 94 {}
N -530 -140 -530 -30 {}
N -530 30 -530 70 {}
N -490 -60 -490 70 {}
N -390 -60 -390 0 {}
N -320 -140 -320 -30 {}
N -320 30 -320 90 {}
N -260 0 -260 94 {}
N -70 0 -70 94 {}
N -70 260 -70 354 {}
N -10 -140 -10 -30 {}
N -10 30 -10 90 {}
N -10 190 -10 230 {}
N -10 290 -10 660 {}
N 30 190 30 260 {}
N 60 -60 60 0 {}
N 110 170 110 260 {}
N 230 200 230 260 {}
N 340 -60 340 0 {}
N 340 520 340 580 {}
N 410 -140 410 -30 {}
N 410 30 410 90 {}
N 410 290 410 490 {}
N 410 550 410 660 {}
N 470 30 470 230 {}
N 470 260 470 354 {}
N 470 520 470 614 {}
N 680 -60 680 0 {}
N 750 -140 750 -30 {}
N 750 30 750 90 {}
N 750 170 750 230 {}
N 750 290 750 660 {}
N 810 0 810 94 {}
N 810 260 810 354 {}
N 1020 520 1020 580 {}
N 1050 0 1050 70 {}
N 1090 -140 1090 -30 {}
N 1090 30 1090 70 {}
N 1090 170 1090 230 {}
N 1090 290 1090 490 {}
N 1090 550 1090 660 {}
N 1150 0 1150 94 {}
N 1150 260 1150 354 {}
N 1150 520 1150 614 {}
N 1315 200 1315 230 {}
N 1315 290 1315 320 {}
N 1375 60 1375 200 {}
N 1375 260 1375 354 {}
N 1465 520 1465 580 {}
N 1495 -60 1495 0 {}
N 1535 -140 1535 -30 {}
N 1535 30 1535 90 {}
N 1535 170 1535 230 {}
N 1535 290 1535 320 {}
N 1535 320 1535 490 {}
N 1535 550 1535 660 {}
N 1595 0 1595 94 {}
N 1595 260 1595 354 {}
N 1595 520 1595 614 {}
N 1740 170 1740 230 {}
N 1740 290 1740 350 {}
N 1940 -60 1940 0 {}
N 1980 -140 1980 -30 {}
N 1980 30 1980 90 {}
N 1980 290 1980 660 {}
N 2040 60 2040 230 {}
N 2040 260 2040 354 {}
N 2280 200 2280 230 {}
N 2280 290 2280 320 {}
N 2340 260 2340 354 {}
N -2030 -140 2760 -140 {}
N -800 -60 -490 -60 {}
N -390 -60 60 -60 {}
N 340 -60 680 -60 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -420 0 -360 0 {}
N -320 0 -260 0 {}
N -70 0 -10 0 {}
N 30 0 370 0 {}
N 680 0 710 0 {}
N 750 0 810 0 {}
N 990 0 1050 0 {}
N 1090 0 1150 0 {}
N 1465 0 1495 0 {}
N 1535 0 1595 0 {}
N 1910 0 1940 0 {}
N 410 30 470 30 {}
N -930 60 -870 60 {}
N -320 60 1375 60 {}
N 1980 60 2040 60 {}
N -530 70 -490 70 {}
N 1050 70 1090 70 {}
N -870 170 110 170 {}
N -1550 190 -1510 190 {}
N -10 190 30 190 {}
N -800 200 230 200 {}
N 1255 200 2280 200 {}
N -930 230 -870 230 {}
N 410 230 470 230 {}
N 1980 230 2040 230 {}
N -1610 260 -1550 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -930 260 -870 260 {}
N -830 260 -770 260 {}
N -70 260 -10 260 {}
N 110 260 140 260 {}
N 200 260 230 260 {}
N 310 260 370 260 {}
N 410 260 470 260 {}
N 650 260 710 260 {}
N 750 260 810 260 {}
N 990 260 1050 260 {}
N 1090 260 1150 260 {}
N 1185 260 1275 260 {}
N 1315 260 1375 260 {}
N 1435 260 1495 260 {}
N 1535 260 1595 260 {}
N 1880 260 1940 260 {}
N 1980 260 2040 260 {}
N 2150 260 2240 260 {}
N 2280 260 2340 260 {}
N 1090 320 1315 320 {}
N 1475 320 2280 320 {}
N -1270 520 -1210 520 {}
N -1170 520 370 520 {}
N 410 520 470 520 {}
N 1020 520 1050 520 {}
N 1090 520 1150 520 {}
N 1465 520 1495 520 {}
N 1535 520 1595 520 {}
N 340 580 1465 580 {}
N -2030 660 2760 660 {}
C {devices/lab_wire.sym} 410 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} 1090 350 2 0 {name=l1 lab=DM_2}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l2 lab=VB3}
C {devices/lab_wire.sym} -10 90 2 0 {name=l3 lab=VB3}
C {devices/lab_wire.sym} -10 230 0 0 {name=l4 lab=VB3}
C {devices/lab_wire.sym} 310 260 0 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 990 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 1435 260 0 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} -1210 170 0 1 {name=l9 lab=VB4}
C {devices/lab_wire.sym} -1110 520 0 1 {name=l10 lab=VB4}
C {devices/lab_wire.sym} 1740 350 2 0 {name=l11 lab=VOUT}
C {devices/lab_wire.sym} 1980 90 2 0 {name=l12 lab=VOUT}
C {devices/lab_wire.sym} 990 0 0 0 {name=l13 lab=VOUTN}
C {devices/lab_wire.sym} 1090 170 0 1 {name=l14 lab=VOUTN}
C {devices/lab_wire.sym} 1495 -60 0 1 {name=l15 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l16 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l17 lab=net013}
C {devices/lab_wire.sym} -420 0 0 0 {name=l18 lab=net013}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l19 lab=net043}
C {devices/lab_wire.sym} 650 260 0 0 {name=l20 lab=net043}
C {devices/lab_wire.sym} -770 260 0 1 {name=l21 lab=net049}
C {devices/lab_wire.sym} 750 90 2 0 {name=l22 lab=net049}
C {devices/lab_wire.sym} 750 170 0 1 {name=l23 lab=net049}
C {devices/lab_wire.sym} 1880 260 0 0 {name=l24 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l25 lab=net050}
C {devices/lab_wire.sym} 1535 90 2 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1535 170 0 1 {name=l27 lab=net050}
C {devices/lab_wire.sym} 1740 170 0 1 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1940 -60 0 1 {name=l29 lab=net050}
C {devices/lab_wire.sym} 1535 350 2 0 {name=l30 lab=net063}
C {devices/lab_wire.sym} -870 90 2 0 {name=l31 lab=net1}
C {devices/lab_wire.sym} -320 90 2 0 {name=l32 lab=net31}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l33 lab=net54}
C {devices/lab_wire.sym} 410 350 2 0 {name=l34 lab=net56}
C {devices/lab_wire.sym} 2340 354 2 0 {name=l35 lab=net31}
C {devices/lab_wire.sym} 1375 354 2 0 {name=l36 lab=net31}
C {devices/lab_wire.sym} -590 94 2 0 {name=l37 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l38 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l39 lab=vdd}
C {devices/lab_wire.sym} 1980 0 0 0 {name=l40 lab=vdd}
C {devices/lab_wire.sym} 410 0 0 0 {name=l41 lab=vdd}
C {devices/lab_wire.sym} -70 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} -260 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} 1150 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} 1595 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 810 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} -870 0 0 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l48 lab=vss}
C {devices/lab_wire.sym} 470 354 2 0 {name=l49 lab=vss}
C {devices/lab_wire.sym} -70 354 2 0 {name=l50 lab=vss}
C {devices/lab_wire.sym} 1150 354 2 0 {name=l51 lab=vss}
C {devices/lab_wire.sym} 1595 354 2 0 {name=l52 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} 470 614 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} 1150 614 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} 1595 614 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} 810 354 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} 2040 354 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l61 lab=net013}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l62 lab=vss}
C {devices/ipin.sym} 1185 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2150 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
B 8 -1646 -78 1186 78 {fill=0}
T {PMOS Simple Current Mirror (6 outputs)} -1646 -96 0 0 0.3 0.3 {layer=8}
B 10 -1670 182 870 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1670 164 0 0 0.3 0.3 {layer=10}
B 12 -2010 182 1210 338 {fill=0}
T {NMOS Simple Current Mirror} -2010 164 0 0 0.3 0.3 {layer=12}
B 21 1000 -78 1971 78 {fill=0}
T {PMOS Simple Current Mirror} 1000 -96 0 0 0.3 0.3 {layer=21}
B 15 1225 182 2740 338 {fill=0}
T {PMOS Differential Pair} 1225 164 0 0 0.3 0.3 {layer=15}
