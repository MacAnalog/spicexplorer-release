v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_013_qu2017_azc} -2250 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 0 390 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} -850 520 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/capa_np.sym} 2075 520 0 0 {name=C2 value='CAPACITOR_2'}
C {devices/isource_np.sym} -2210 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} -690 390 1 0 {name=R0 value='RESISTOR_0'}
C {devices/res_np.sym} -935 390 1 0 {name=R1 value='RESISTOR_1'}
C {devices/res_np.sym} 710 260 1 0 {name=R2 value='RESISTOR_2'}
C {devices/res_np.sym} 2330 260 1 0 {name=R3 value='RESISTOR_3'}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1445 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} 1735 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M13 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 890 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1255 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1870 520 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -170 260 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 0 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 890 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1255 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 2075 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 520 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_pmos_np.sym} 180 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 890 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1255 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1735 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 2075 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 520 0 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1075 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -2210 430 -2210 490 {}
N -2210 550 -2210 610 {}
N -1950 520 -1950 614 {}
N -1890 430 -1890 490 {}
N -1890 550 -1890 660 {}
N -1610 520 -1610 614 {}
N -1550 430 -1550 490 {}
N -1550 550 -1550 660 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 230 {}
N -1210 290 -1210 660 {}
N -905 390 -905 450 {}
N -850 550 -850 660 {}
N -830 -140 -830 -30 {}
N -830 30 -830 90 {}
N -830 170 -830 230 {}
N -830 290 -830 660 {}
N -770 0 -770 94 {}
N -770 260 -770 354 {}
N -660 390 -660 450 {}
N -630 390 -630 460 {}
N -590 0 -590 94 {}
N -530 -140 -530 -30 {}
N -530 30 -530 70 {}
N -490 0 -490 70 {}
N -250 0 -250 94 {}
N -250 260 -250 354 {}
N -190 -140 -190 -30 {}
N -190 30 -190 90 {}
N -190 170 -190 230 {}
N -190 290 -190 660 {}
N -150 0 -150 60 {}
N -150 190 -150 260 {}
N -120 0 -120 60 {}
N -60 390 -60 520 {}
N 20 -140 20 -30 {}
N 20 30 20 90 {}
N 30 390 30 450 {}
N 80 0 80 94 {}
N 160 -60 160 0 {}
N 200 -140 200 -30 {}
N 200 30 200 90 {}
N 260 0 260 94 {}
N 540 -140 540 -30 {}
N 540 30 540 90 {}
N 540 170 540 230 {}
N 540 290 540 660 {}
N 600 0 600 94 {}
N 600 260 600 354 {}
N 740 260 740 320 {}
N 870 0 870 70 {}
N 870 200 870 260 {}
N 910 -140 910 -30 {}
N 910 30 910 70 {}
N 910 170 910 230 {}
N 910 290 910 490 {}
N 910 550 910 660 {}
N 970 0 970 94 {}
N 970 260 970 354 {}
N 970 520 970 614 {}
N 1055 200 1055 260 {}
N 1095 170 1095 230 {}
N 1095 290 1095 320 {}
N 1155 260 1155 354 {}
N 1205 0 1205 60 {}
N 1205 260 1205 390 {}
N 1235 200 1235 260 {}
N 1275 -140 1275 -30 {}
N 1275 30 1275 90 {}
N 1275 170 1275 230 {}
N 1275 290 1275 490 {}
N 1275 550 1275 660 {}
N 1335 0 1335 94 {}
N 1335 260 1335 354 {}
N 1335 520 1335 614 {}
N 1425 200 1425 260 {}
N 1465 170 1465 230 {}
N 1465 290 1465 320 {}
N 1525 260 1525 354 {}
N 1655 0 1655 94 {}
N 1655 260 1655 354 {}
N 1715 -140 1715 -30 {}
N 1715 30 1715 70 {}
N 1715 170 1715 230 {}
N 1715 290 1715 660 {}
N 1755 0 1755 70 {}
N 1785 200 1785 260 {}
N 2025 0 2025 60 {}
N 2075 260 2075 490 {}
N 2075 550 2075 660 {}
N 2095 -140 2095 -30 {}
N 2095 30 2095 230 {}
N 2095 290 2095 660 {}
N 2155 0 2155 94 {}
N 2155 260 2155 354 {}
N 2300 200 2300 260 {}
N 2360 260 2360 320 {}
N -2270 -140 2530 -140 {}
N -1270 0 -1210 0 {}
N -1170 0 -870 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -490 0 -430 0 {}
N -250 0 -190 0 {}
N -150 0 -20 0 {}
N 20 0 80 0 {}
N 130 0 160 0 {}
N 200 0 260 0 {}
N 440 0 500 0 {}
N 540 0 600 0 {}
N 810 0 870 0 {}
N 910 0 970 0 {}
N 1175 0 1235 0 {}
N 1275 0 1335 0 {}
N 1655 0 1715 0 {}
N 1755 0 1815 0 {}
N 2025 0 2055 0 {}
N 2095 0 2155 0 {}
N 1715 60 2025 60 {}
N -530 70 -490 70 {}
N 870 70 910 70 {}
N 1715 70 1755 70 {}
N -190 190 -150 190 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -930 260 -850 260 {}
N -830 260 -770 260 {}
N -250 260 -190 260 {}
N 440 260 500 260 {}
N 540 260 600 260 {}
N 620 260 680 260 {}
N 740 260 770 260 {}
N 910 260 970 260 {}
N 1025 260 1055 260 {}
N 1095 260 1155 260 {}
N 1205 260 1235 260 {}
N 1275 260 1335 260 {}
N 1395 260 1425 260 {}
N 1465 260 1525 260 {}
N 1655 260 1715 260 {}
N 1755 260 1815 260 {}
N 1995 260 2075 260 {}
N 2095 260 2155 260 {}
N 2270 260 2300 260 {}
N 2360 260 2390 260 {}
N 910 320 1095 320 {}
N 1275 320 1465 320 {}
N -1025 390 -965 390 {}
N -905 390 -875 390 {}
N -780 390 -720 390 {}
N -660 390 -630 390 {}
N -90 390 -30 390 {}
N 30 390 60 390 {}
N -910 490 -850 490 {}
N -1950 520 -1890 520 {}
N -1850 520 -1790 520 {}
N -1610 520 -1550 520 {}
N -1510 520 -60 520 {}
N 810 520 870 520 {}
N 910 520 970 520 {}
N 1175 520 1235 520 {}
N 1275 520 1335 520 {}
N -2270 660 2530 660 {}
C {devices/lab_wire.sym} -2270 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -2270 660 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} -1790 520 0 1 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} 910 350 2 0 {name=l3 lab=DM_2}
C {devices/lab_wire.sym} -430 0 0 1 {name=l4 lab=VB1}
C {devices/lab_wire.sym} -150 60 2 0 {name=l5 lab=VB1}
C {devices/lab_wire.sym} 160 -60 0 1 {name=l6 lab=VB1}
C {devices/lab_wire.sym} 440 0 0 0 {name=l7 lab=VB1}
C {devices/lab_wire.sym} -190 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} -190 170 0 1 {name=l9 lab=VB4}
C {devices/lab_wire.sym} 810 520 0 0 {name=l10 lab=VB4}
C {devices/lab_wire.sym} 1175 520 0 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} 1055 200 0 1 {name=l12 lab=VINN}
C {devices/lab_wire.sym} 1425 200 0 1 {name=l13 lab=VINP}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l14 lab=VOUT}
C {devices/lab_wire.sym} 30 450 2 0 {name=l15 lab=VOUT}
C {devices/lab_wire.sym} 810 0 0 0 {name=l16 lab=VOUTN}
C {devices/lab_wire.sym} 910 170 0 1 {name=l17 lab=VOUTN}
C {devices/lab_wire.sym} 1175 0 0 0 {name=l18 lab=VOUTN}
C {devices/lab_wire.sym} 20 90 2 0 {name=l19 lab=net019}
C {devices/lab_wire.sym} 1095 170 0 1 {name=l20 lab=net019}
C {devices/lab_wire.sym} 1465 170 0 1 {name=l21 lab=net019}
C {devices/lab_wire.sym} 1995 260 0 0 {name=l22 lab=net043}
C {devices/lab_wire.sym} 2360 320 2 0 {name=l23 lab=net043}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l24 lab=net049}
C {devices/lab_wire.sym} 540 90 2 0 {name=l25 lab=net049}
C {devices/lab_wire.sym} 540 170 0 1 {name=l26 lab=net049}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l27 lab=net050}
C {devices/lab_wire.sym} 1275 90 2 0 {name=l28 lab=net050}
C {devices/lab_wire.sym} 1275 170 0 1 {name=l29 lab=net050}
C {devices/lab_wire.sym} -930 260 0 0 {name=l30 lab=net051}
C {devices/lab_wire.sym} -910 490 0 0 {name=l31 lab=net051}
C {devices/lab_wire.sym} 740 320 2 0 {name=l32 lab=net051}
C {devices/lab_wire.sym} 1815 0 0 1 {name=l33 lab=net055}
C {devices/lab_wire.sym} 1715 170 0 1 {name=l34 lab=net055}
C {devices/lab_wire.sym} 440 260 0 0 {name=l35 lab=net057}
C {devices/lab_wire.sym} 620 260 0 0 {name=l36 lab=net057}
C {devices/lab_wire.sym} 2095 90 2 0 {name=l37 lab=net057}
C {devices/lab_wire.sym} 2300 200 0 1 {name=l38 lab=net057}
C {devices/lab_wire.sym} -90 390 0 0 {name=l39 lab=net063}
C {devices/lab_wire.sym} 1275 350 2 0 {name=l40 lab=net063}
C {devices/lab_wire.sym} -1890 430 0 1 {name=l41 lab=net077}
C {devices/lab_wire.sym} -660 450 2 0 {name=l42 lab=net077}
C {devices/lab_wire.sym} 870 200 0 1 {name=l43 lab=net077}
C {devices/lab_wire.sym} -1025 390 0 0 {name=l44 lab=net078}
C {devices/lab_wire.sym} -780 390 0 0 {name=l45 lab=net078}
C {devices/lab_wire.sym} 200 90 2 0 {name=l46 lab=net078}
C {devices/lab_wire.sym} -1550 430 0 1 {name=l47 lab=net082}
C {devices/lab_wire.sym} -905 450 2 0 {name=l48 lab=net082}
C {devices/lab_wire.sym} 1235 200 0 1 {name=l49 lab=net082}
C {devices/lab_wire.sym} -830 90 2 0 {name=l50 lab=net094}
C {devices/lab_wire.sym} -830 170 0 1 {name=l51 lab=net094}
C {devices/lab_wire.sym} 1815 260 0 1 {name=l52 lab=net094}
C {devices/lab_wire.sym} 1525 354 2 0 {name=l53 lab=net019}
C {devices/lab_wire.sym} 1155 354 2 0 {name=l54 lab=net019}
C {devices/lab_wire.sym} -590 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -250 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} -770 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 80 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 260 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} 970 94 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} 1335 94 2 0 {name=l62 lab=vdd}
C {devices/lab_wire.sym} 1655 94 2 0 {name=l63 lab=vdd}
C {devices/lab_wire.sym} 2155 94 2 0 {name=l64 lab=vdd}
C {devices/lab_wire.sym} 600 94 2 0 {name=l65 lab=vdd}
C {devices/lab_wire.sym} 1655 354 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} 970 354 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} 1335 354 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} -1950 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} -250 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 970 614 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} 1335 614 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} -770 354 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} 2155 354 2 0 {name=l76 lab=vss}
C {devices/lab_wire.sym} 600 354 2 0 {name=l77 lab=vss}
C {devices/lab_wire.sym} -2210 610 2 0 {name=l78 lab=vss}
C {devices/lab_wire.sym} -2210 430 0 1 {name=l79 lab=VB1}
C {devices/ipin.sym} -2410 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -2410 380 0 0 {name=p1 lab=VINP}
B 8 -698 -78 708 78 {fill=0}
T {PMOS Simple Current Mirror (4 outputs)} -698 -96 0 0 0.3 0.3 {layer=8}
B 10 -366 182 1451 598 {fill=0}
T {NMOS Simple Current Mirror (2 outputs)} -366 164 0 0 0.3 0.3 {layer=10}
B 12 820 -78 1443 78 {fill=0}
T {PMOS Simple Current Mirror} 820 -96 0 0 0.3 0.3 {layer=12}
B 21 1547 -78 2263 78 {fill=0}
T {PMOS Simple Current Mirror} 1547 -96 0 0 0.3 0.3 {layer=21}
B 15 1005 182 1641 338 {fill=0}
T {PMOS Differential Pair} 1005 164 0 0 0.3 0.3 {layer=15}
