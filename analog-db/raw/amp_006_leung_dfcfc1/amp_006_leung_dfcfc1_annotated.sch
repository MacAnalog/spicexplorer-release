v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_006_leung_dfcfc1} -1910 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1510 260 0 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 95 260 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1870 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -510 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1990 260 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 1690 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 275 260 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -65 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 955 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1325 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 275 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 275 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 955 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1325 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} 615 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} -850 260 0 1 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 1690 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} -65 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -340 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 955 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1325 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 615 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} -850 0 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 1145 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1870 430 -1870 490 {}
N -1870 550 -1870 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 90 {}
N -1210 170 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 660 {}
N -930 0 -930 94 {}
N -930 260 -930 354 {}
N -870 -140 -870 -30 {}
N -870 30 -870 90 {}
N -870 170 -870 230 {}
N -870 290 -870 660 {}
N -590 0 -590 94 {}
N -530 -140 -530 -30 {}
N -530 30 -530 70 {}
N -490 0 -490 70 {}
N -360 -60 -360 0 {}
N -320 -140 -320 -30 {}
N -320 30 -320 90 {}
N -260 0 -260 94 {}
N -145 0 -145 94 {}
N -145 260 -145 354 {}
N -85 -140 -85 -30 {}
N -85 30 -85 90 {}
N -85 170 -85 230 {}
N -85 290 -85 660 {}
N -45 190 -45 260 {}
N 65 200 65 260 {}
N 125 260 125 320 {}
N 255 200 255 260 {}
N 295 -140 295 -30 {}
N 295 30 295 90 {}
N 295 170 295 230 {}
N 295 290 295 490 {}
N 295 550 295 660 {}
N 355 0 355 94 {}
N 355 260 355 354 {}
N 355 520 355 614 {}
N 565 200 565 260 {}
N 635 -140 635 -30 {}
N 635 30 635 90 {}
N 635 170 635 230 {}
N 635 290 635 660 {}
N 695 0 695 94 {}
N 695 260 695 354 {}
N 935 0 935 70 {}
N 975 -140 975 -30 {}
N 975 30 975 70 {}
N 975 170 975 230 {}
N 975 290 975 490 {}
N 975 550 975 660 {}
N 1035 0 1035 94 {}
N 1035 260 1035 354 {}
N 1035 520 1035 614 {}
N 1125 200 1125 260 {}
N 1165 170 1165 230 {}
N 1165 290 1165 320 {}
N 1225 260 1225 354 {}
N 1275 0 1275 60 {}
N 1305 200 1305 260 {}
N 1345 -140 1345 -30 {}
N 1345 30 1345 90 {}
N 1345 170 1345 230 {}
N 1345 290 1345 490 {}
N 1345 550 1345 660 {}
N 1405 0 1405 94 {}
N 1405 260 1405 354 {}
N 1405 520 1405 614 {}
N 1510 170 1510 230 {}
N 1510 290 1510 350 {}
N 1670 200 1670 260 {}
N 1710 -140 1710 -30 {}
N 1710 30 1710 90 {}
N 1710 170 1710 230 {}
N 1710 290 1710 350 {}
N 1770 0 1770 94 {}
N 1770 260 1770 354 {}
N 1970 200 1970 260 {}
N 2010 170 2010 230 {}
N 2010 290 2010 350 {}
N 2070 260 2070 354 {}
N -1930 -140 2205 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -930 0 -870 0 {}
N -830 0 -770 0 {}
N -590 0 -530 0 {}
N -390 0 -360 0 {}
N -320 0 -260 0 {}
N -145 0 -85 0 {}
N -45 0 255 0 {}
N 295 0 355 0 {}
N 535 0 595 0 {}
N 635 0 695 0 {}
N 875 0 935 0 {}
N 975 0 1035 0 {}
N 1245 0 1305 0 {}
N 1345 0 1405 0 {}
N 1510 0 1670 0 {}
N 1710 0 1770 0 {}
N -530 70 -490 70 {}
N 935 70 975 70 {}
N -1550 190 -1510 190 {}
N -85 190 -45 190 {}
N -1610 260 -1550 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -930 260 -870 260 {}
N -830 260 -770 260 {}
N -145 260 -85 260 {}
N 35 260 65 260 {}
N 125 260 155 260 {}
N 225 260 255 260 {}
N 295 260 355 260 {}
N 535 260 595 260 {}
N 635 260 695 260 {}
N 875 260 935 260 {}
N 975 260 1035 260 {}
N 1095 260 1125 260 {}
N 1165 260 1225 260 {}
N 1275 260 1305 260 {}
N 1345 260 1405 260 {}
N 1640 260 1670 260 {}
N 1710 260 1770 260 {}
N 1940 260 1970 260 {}
N 2010 260 2070 260 {}
N 975 320 1165 320 {}
N -1270 520 -1210 520 {}
N -1170 520 255 520 {}
N 295 520 355 520 {}
N 875 520 935 520 {}
N 975 520 1035 520 {}
N 1245 520 1305 520 {}
N 1345 520 1405 520 {}
N -1930 660 2205 660 {}
C {devices/lab_wire.sym} -1930 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -1930 660 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} 295 90 2 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} 295 170 0 1 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 975 350 2 0 {name=l4 lab=DM_2}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} -85 90 2 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} -85 170 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 255 200 0 1 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 875 260 0 0 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 1305 200 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -1210 90 2 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -1210 170 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -1110 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 875 520 0 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 1245 520 0 0 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1125 200 0 1 {name=l16 lab=VINN}
C {devices/lab_wire.sym} 1970 200 0 1 {name=l17 lab=VINP}
C {devices/lab_wire.sym} 1510 350 2 0 {name=l18 lab=VOUT}
C {devices/lab_wire.sym} 1710 90 2 0 {name=l19 lab=VOUT}
C {devices/lab_wire.sym} 1710 170 0 1 {name=l20 lab=VOUT}
C {devices/lab_wire.sym} 875 0 0 0 {name=l21 lab=VOUTN}
C {devices/lab_wire.sym} 975 170 0 1 {name=l22 lab=VOUTN}
C {devices/lab_wire.sym} 1245 0 0 0 {name=l23 lab=VOUTN}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l24 lab=net013}
C {devices/lab_wire.sym} -770 0 0 1 {name=l25 lab=net013}
C {devices/lab_wire.sym} -490 60 2 0 {name=l26 lab=net013}
C {devices/lab_wire.sym} -360 -60 0 1 {name=l27 lab=net013}
C {devices/lab_wire.sym} 15 0 0 1 {name=l28 lab=net013}
C {devices/lab_wire.sym} 535 0 0 0 {name=l29 lab=net013}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l30 lab=net043}
C {devices/lab_wire.sym} 535 260 0 0 {name=l31 lab=net043}
C {devices/lab_wire.sym} -770 260 0 1 {name=l32 lab=net049}
C {devices/lab_wire.sym} 125 320 2 0 {name=l33 lab=net049}
C {devices/lab_wire.sym} 635 90 2 0 {name=l34 lab=net049}
C {devices/lab_wire.sym} 635 170 0 1 {name=l35 lab=net049}
C {devices/lab_wire.sym} 1670 200 0 1 {name=l36 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l37 lab=net050}
C {devices/lab_wire.sym} 1345 90 2 0 {name=l38 lab=net050}
C {devices/lab_wire.sym} 1345 170 0 1 {name=l39 lab=net050}
C {devices/lab_wire.sym} 1510 170 0 1 {name=l40 lab=net050}
C {devices/lab_wire.sym} 1610 0 0 0 {name=l41 lab=net050}
C {devices/lab_wire.sym} 1345 350 2 0 {name=l42 lab=net063}
C {devices/lab_wire.sym} 2010 350 2 0 {name=l43 lab=net063}
C {devices/lab_wire.sym} -870 90 2 0 {name=l44 lab=net1}
C {devices/lab_wire.sym} -870 170 0 1 {name=l45 lab=net1}
C {devices/lab_wire.sym} 65 200 0 1 {name=l46 lab=net1}
C {devices/lab_wire.sym} -320 90 2 0 {name=l47 lab=net31}
C {devices/lab_wire.sym} 1165 170 0 1 {name=l48 lab=net31}
C {devices/lab_wire.sym} 2010 170 0 1 {name=l49 lab=net31}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l50 lab=net54}
C {devices/lab_wire.sym} 295 350 2 0 {name=l51 lab=net56}
C {devices/lab_wire.sym} 2070 354 2 0 {name=l52 lab=net31}
C {devices/lab_wire.sym} 1225 354 2 0 {name=l53 lab=net31}
C {devices/lab_wire.sym} -590 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 1770 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 355 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} -145 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} -260 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} 1035 94 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} 1405 94 2 0 {name=l62 lab=vdd}
C {devices/lab_wire.sym} 695 94 2 0 {name=l63 lab=vdd}
C {devices/lab_wire.sym} -930 94 2 0 {name=l64 lab=vdd}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} 355 354 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} -145 354 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} 1035 354 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} 1405 354 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 355 614 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} 1035 614 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 1405 614 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} 695 354 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} -930 354 2 0 {name=l76 lab=vss}
C {devices/lab_wire.sym} 1770 354 2 0 {name=l77 lab=vss}
C {devices/lab_wire.sym} -1870 430 0 1 {name=l78 lab=net013}
C {devices/lab_wire.sym} -1870 610 2 0 {name=l79 lab=vss}
C {devices/lab_wire.sym} 1710 350 2 0 {name=l80 lab=vss}
C {devices/ipin.sym} -2070 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -2070 380 0 0 {name=p1 lab=VINP}
B 8 -1378 -78 803 78 {fill=0}
T {PMOS Simple Current Mirror (6 outputs)} -1378 -96 0 0 0.3 0.3 {layer=8}
B 10 -1386 182 471 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1386 164 0 0 0.3 0.3 {layer=10}
B 12 -1726 182 811 338 {fill=0}
T {NMOS Simple Current Mirror} -1726 164 0 0 0.3 0.3 {layer=12}
B 21 885 -78 1513 78 {fill=0}
T {PMOS Simple Current Mirror} 885 -96 0 0 0.3 0.3 {layer=21}
B 15 1075 182 2186 338 {fill=0}
T {PMOS Differential Pair} 1075 164 0 0 0.3 0.3 {layer=15}
