v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {slice level 0 -- sheet of record} -40 -200 0 0 0.4 0.4 {}
N -40 -140 100 -140 { lab=out_a}
N -40 -140 -40 -40 { lab=out_a}
N -40 -40 100 -40 { lab=in_a}
