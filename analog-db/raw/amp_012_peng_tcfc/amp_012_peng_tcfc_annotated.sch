v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_012_peng_tcfc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 650 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1435 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} 40 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -640 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1655 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 1995 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -640 520 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -300 520 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 425 520 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1085 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -640 780 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -300 780 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -300 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -1085 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1995 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 425 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 210 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 40 260 0 1 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} -640 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} -1085 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} -300 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 425 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 870 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 870 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 870 0 0 0 {name=M65 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 1210 260 0 0 {name=M66 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm66_w l=x_dut_xm66_l m=x_dut_xm66_m}
C {devices/sg13_lv_nmos_np.sym} 1210 520 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 1210 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 1655 260 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_pmos_np.sym} -1310 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} -870 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 690 -1915 750 {}
N -1915 810 -1915 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1610 520 -1610 614 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 490 {}
N -1550 550 -1550 920 {}
N -1510 0 -1510 70 {}
N -1390 260 -1390 354 {}
N -1330 170 -1330 230 {}
N -1330 290 -1330 320 {}
N -1165 0 -1165 94 {}
N -1165 260 -1165 354 {}
N -1165 520 -1165 614 {}
N -1105 -140 -1105 -30 {}
N -1105 30 -1105 90 {}
N -1105 170 -1105 230 {}
N -1105 290 -1105 490 {}
N -1105 550 -1105 920 {}
N -1095 460 -1095 520 {}
N -1065 0 -1065 60 {}
N -950 260 -950 354 {}
N -890 170 -890 230 {}
N -890 290 -890 320 {}
N -720 0 -720 94 {}
N -720 260 -720 354 {}
N -720 520 -720 614 {}
N -720 780 -720 874 {}
N -660 -140 -660 -30 {}
N -660 30 -660 90 {}
N -660 170 -660 230 {}
N -660 290 -660 490 {}
N -660 550 -660 750 {}
N -660 810 -660 920 {}
N -620 400 -620 520 {}
N -590 780 -590 840 {}
N -380 0 -380 94 {}
N -380 260 -380 354 {}
N -380 520 -380 614 {}
N -380 780 -380 874 {}
N -320 -140 -320 -30 {}
N -320 30 -320 90 {}
N -320 170 -320 230 {}
N -320 290 -320 490 {}
N -320 550 -320 750 {}
N -320 810 -320 920 {}
N -250 200 -250 260 {}
N -250 400 -250 520 {}
N -250 780 -250 840 {}
N -40 60 -40 230 {}
N -40 260 -40 354 {}
N 20 -140 20 -30 {}
N 20 30 20 90 {}
N 20 290 20 320 {}
N 60 0 60 60 {}
N 90 200 90 260 {}
N 150 0 150 320 {}
N 160 -60 160 0 {}
N 230 -140 230 -30 {}
N 230 30 230 90 {}
N 290 0 290 94 {}
N 315 200 315 260 {}
N 375 -60 375 0 {}
N 385 60 385 230 {}
N 405 450 405 520 {}
N 445 -140 445 -30 {}
N 445 30 445 90 {}
N 445 290 445 490 {}
N 445 550 445 920 {}
N 505 0 505 94 {}
N 505 260 505 354 {}
N 505 520 505 614 {}
N 680 260 680 320 {}
N 850 -60 850 70 {}
N 890 -140 890 -30 {}
N 890 30 890 200 {}
N 890 200 890 230 {}
N 890 290 890 490 {}
N 890 550 890 920 {}
N 950 0 950 94 {}
N 950 260 950 354 {}
N 950 520 950 614 {}
N 1220 200 1220 260 {}
N 1230 -140 1230 -30 {}
N 1230 30 1230 230 {}
N 1230 290 1230 490 {}
N 1230 550 1230 920 {}
N 1290 0 1290 94 {}
N 1290 260 1290 354 {}
N 1290 520 1290 614 {}
N 1435 200 1435 230 {}
N 1435 290 1435 350 {}
N 1635 -60 1635 0 {}
N 1635 190 1635 260 {}
N 1675 -140 1675 -30 {}
N 1675 30 1675 230 {}
N 1675 290 1675 920 {}
N 1735 0 1735 94 {}
N 1735 260 1735 354 {}
N 2015 -140 2015 -30 {}
N 2015 30 2015 230 {}
N 2015 290 2015 920 {}
N 2075 0 2075 94 {}
N 2075 260 2075 354 {}
N -2030 -140 2495 -140 {}
N 160 -60 375 -60 {}
N -1610 0 -1550 0 {}
N -1165 0 -1105 0 {}
N -1065 0 -1035 0 {}
N -720 0 -660 0 {}
N -620 0 -560 0 {}
N -380 0 -320 0 {}
N -280 0 -220 0 {}
N 60 0 190 0 {}
N 230 0 290 0 {}
N 375 0 405 0 {}
N 445 0 505 0 {}
N 890 0 950 0 {}
N 1130 0 1190 0 {}
N 1230 0 1290 0 {}
N 1605 0 1635 0 {}
N 1675 0 1735 0 {}
N 1915 0 1975 0 {}
N 2015 0 2075 0 {}
N -40 60 20 60 {}
N 385 60 445 60 {}
N -1550 70 -1510 70 {}
N 850 70 890 70 {}
N 1635 190 1675 190 {}
N -250 200 90 200 {}
N 315 200 1220 200 {}
N 1230 200 1435 200 {}
N -40 230 20 230 {}
N 385 230 445 230 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -1390 260 -1330 260 {}
N -1290 260 -1260 260 {}
N -1165 260 -1105 260 {}
N -1065 260 -1005 260 {}
N -950 260 -890 260 {}
N -850 260 -820 260 {}
N -720 260 -660 260 {}
N -620 260 -560 260 {}
N -380 260 -320 260 {}
N -280 260 -250 260 {}
N -40 260 20 260 {}
N 60 260 405 260 {}
N 445 260 505 260 {}
N 560 260 620 260 {}
N 680 260 710 260 {}
N 790 260 850 260 {}
N 890 260 950 260 {}
N 1160 260 1220 260 {}
N 1230 260 1290 260 {}
N 1675 260 1735 260 {}
N 1915 260 1975 260 {}
N 2015 260 2075 260 {}
N -1550 320 -1330 320 {}
N -1105 320 -890 320 {}
N 20 320 150 320 {}
N -620 400 -250 400 {}
N 405 450 445 450 {}
N -1095 460 -660 460 {}
N -1610 520 -1550 520 {}
N -1510 520 -1450 520 {}
N -1165 520 -1105 520 {}
N -1095 520 -1035 520 {}
N -720 520 -660 520 {}
N -380 520 -320 520 {}
N -310 520 405 520 {}
N 445 520 505 520 {}
N 790 520 850 520 {}
N 890 520 950 520 {}
N 1130 520 1190 520 {}
N 1230 520 1290 520 {}
N -720 780 -660 780 {}
N -620 780 -560 780 {}
N -380 780 -320 780 {}
N -280 780 -250 780 {}
N -590 840 -250 840 {}
N -2030 920 2495 920 {}
C {devices/lab_wire.sym} -1550 350 2 0 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} -560 0 0 1 {name=l1 lab=VB1}
C {devices/lab_wire.sym} -220 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} 60 60 2 0 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 1130 0 0 0 {name=l4 lab=VB1}
C {devices/lab_wire.sym} -560 260 0 1 {name=l5 lab=VB2}
C {devices/lab_wire.sym} 850 -60 0 1 {name=l6 lab=VB2}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -1005 260 0 1 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 445 350 2 0 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 790 260 0 0 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -1450 520 0 1 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -660 350 2 0 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -560 780 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 790 520 0 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 560 260 0 0 {name=l15 lab=VOUT}
C {devices/lab_wire.sym} 1435 350 2 0 {name=l16 lab=VOUT}
C {devices/lab_wire.sym} 2015 90 2 0 {name=l17 lab=VOUT}
C {devices/lab_wire.sym} -1510 60 2 0 {name=l18 lab=VOUTN}
C {devices/lab_wire.sym} -1065 60 2 0 {name=l19 lab=VOUTN}
C {devices/lab_wire.sym} -1105 90 2 0 {name=l20 lab=VOUTP}
C {devices/lab_wire.sym} -1105 170 0 1 {name=l21 lab=VOUTP}
C {devices/lab_wire.sym} 680 320 2 0 {name=l22 lab=VOUTP}
C {devices/lab_wire.sym} 1635 -60 0 1 {name=l23 lab=VOUTP}
C {devices/lab_wire.sym} 1915 0 0 0 {name=l24 lab=VOUTP}
C {devices/lab_wire.sym} 1130 520 0 0 {name=l25 lab=net043}
C {devices/lab_wire.sym} 1675 90 2 0 {name=l26 lab=net043}
C {devices/lab_wire.sym} 1230 90 2 0 {name=l27 lab=net049}
C {devices/lab_wire.sym} -1105 350 2 0 {name=l28 lab=net063}
C {devices/lab_wire.sym} 1230 350 2 0 {name=l29 lab=net10}
C {devices/lab_wire.sym} 1915 260 0 0 {name=l30 lab=net10}
C {devices/lab_wire.sym} 20 90 2 0 {name=l31 lab=net2}
C {devices/lab_wire.sym} -660 90 2 0 {name=l32 lab=net3}
C {devices/lab_wire.sym} -660 170 0 1 {name=l33 lab=net3}
C {devices/lab_wire.sym} -1330 170 0 1 {name=l34 lab=net31}
C {devices/lab_wire.sym} -890 170 0 1 {name=l35 lab=net31}
C {devices/lab_wire.sym} 230 90 2 0 {name=l36 lab=net31}
C {devices/lab_wire.sym} -660 610 2 0 {name=l37 lab=net54}
C {devices/lab_wire.sym} -320 610 2 0 {name=l38 lab=net56}
C {devices/lab_wire.sym} -320 90 2 0 {name=l39 lab=net6}
C {devices/lab_wire.sym} -320 170 0 1 {name=l40 lab=net6}
C {devices/lab_wire.sym} -320 350 2 0 {name=l41 lab=net7}
C {devices/lab_wire.sym} 445 90 2 0 {name=l42 lab=net8}
C {devices/lab_wire.sym} 890 350 2 0 {name=l43 lab=net9}
C {devices/lab_wire.sym} -1390 354 2 0 {name=l44 lab=net31}
C {devices/lab_wire.sym} -950 354 2 0 {name=l45 lab=net31}
C {devices/lab_wire.sym} 20 0 0 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} -720 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 1735 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} 2075 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} -380 94 2 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} 505 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} 290 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -40 354 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} -720 354 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -1165 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} -380 354 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 505 354 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 950 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 1290 354 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} 1290 94 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} -720 614 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -380 614 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} 505 614 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -1165 354 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} -720 874 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} -380 874 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} -1165 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 2075 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} 950 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 950 614 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} 1290 614 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} 1735 354 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} -1915 690 0 1 {name=l76 lab=VB1}
C {devices/lab_wire.sym} -1915 870 2 0 {name=l77 lab=vss}
C {devices/ipin.sym} -1260 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -820 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 920 0 0 {name=p3 lab=vss}
B 8 -1120 182 1350 858 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror (2 outputs) [alt: cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode]} -1120 164 0 0 0.3 0.3 {layer=8}
B 10 -1986 -78 -1015 78 {fill=0}
T {PMOS Simple Current Mirror} -1986 -96 0 0 0.3 0.3 {layer=10}
B 12 -1120 -78 1350 338 {fill=0}
T {PMOS Improved High Swing Cascode Current Mirror (3 outputs) [alt: cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode]} -1120 -96 0 0 0.3 0.3 {layer=12}
B 21 1140 182 2135 598 {fill=0}
T {NMOS Simple Current Mirror} 1140 164 0 0 0.3 0.3 {layer=21}
B 15 -1766 182 -800 338 {fill=0}
T {PMOS Differential Pair} -1766 164 0 0 0.3 0.3 {layer=15}
