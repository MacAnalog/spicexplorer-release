v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_011_peng_iac} -2200 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -1820 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 690 520 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -2160 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 850 780 0 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} 620 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -80 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -820 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -80 520 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 280 520 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 960 520 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -445 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -80 780 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 280 780 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 280 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -445 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 960 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 100 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 620 260 0 1 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} -80 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} -445 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 280 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 960 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 1300 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 1300 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 1300 0 0 0 {name=M65 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 1640 260 0 0 {name=M66 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm66_w l=x_dut_xm66_l m=x_dut_xm66_m}
C {devices/sg13_lv_nmos_np.sym} -820 260 0 1 {name=M67 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm67_w l=x_dut_xm67_l m=x_dut_xm67_m}
C {devices/sg13_lv_nmos_np.sym} -820 520 0 1 {name=M68 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_nmos_np.sym} 1640 520 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 1640 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} -635 520 0 1 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_pmos_np.sym} -1010 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} -265 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -2160 690 -2160 750 {}
N -2160 810 -2160 870 {}
N -1790 260 -1790 320 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 920 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 920 {}
N -1170 0 -1170 70 {}
N -1090 260 -1090 354 {}
N -1030 170 -1030 230 {}
N -1030 290 -1030 320 {}
N -990 260 -990 320 {}
N -900 0 -900 94 {}
N -900 260 -900 354 {}
N -900 520 -900 614 {}
N -840 -140 -840 -30 {}
N -840 30 -840 90 {}
N -840 170 -840 230 {}
N -840 290 -840 490 {}
N -840 550 -840 920 {}
N -800 520 -800 580 {}
N -715 520 -715 614 {}
N -655 460 -655 490 {}
N -655 550 -655 920 {}
N -615 520 -615 580 {}
N -525 0 -525 94 {}
N -525 260 -525 354 {}
N -525 520 -525 614 {}
N -465 -140 -465 -30 {}
N -465 30 -465 90 {}
N -465 170 -465 230 {}
N -465 290 -465 490 {}
N -465 550 -465 920 {}
N -395 0 -395 60 {}
N -345 260 -345 354 {}
N -285 170 -285 230 {}
N -285 290 -285 320 {}
N -245 260 -245 320 {}
N -160 0 -160 94 {}
N -160 260 -160 354 {}
N -160 520 -160 614 {}
N -160 780 -160 874 {}
N -100 -140 -100 -30 {}
N -100 30 -100 90 {}
N -100 170 -100 230 {}
N -100 290 -100 490 {}
N -100 550 -100 750 {}
N -100 810 -100 920 {}
N -60 0 -60 60 {}
N 20 0 20 94 {}
N 80 -140 80 -30 {}
N 80 30 80 200 {}
N 120 0 120 60 {}
N 200 0 200 94 {}
N 200 260 200 354 {}
N 200 520 200 614 {}
N 200 780 200 874 {}
N 260 -140 260 -30 {}
N 260 30 260 230 {}
N 260 290 260 490 {}
N 260 550 260 750 {}
N 260 810 260 920 {}
N 540 0 540 94 {}
N 540 260 540 354 {}
N 600 -140 600 -30 {}
N 600 30 600 230 {}
N 600 290 600 350 {}
N 720 520 720 580 {}
N 850 520 850 750 {}
N 850 810 850 920 {}
N 940 450 940 520 {}
N 980 -140 980 -30 {}
N 980 30 980 230 {}
N 980 290 980 490 {}
N 980 550 980 920 {}
N 1040 0 1040 94 {}
N 1040 260 1040 354 {}
N 1040 520 1040 614 {}
N 1280 0 1280 70 {}
N 1320 -140 1320 -30 {}
N 1320 30 1320 230 {}
N 1320 290 1320 490 {}
N 1320 550 1320 920 {}
N 1380 0 1380 94 {}
N 1380 260 1380 354 {}
N 1380 520 1380 614 {}
N 1660 -140 1660 -30 {}
N 1660 30 1660 230 {}
N 1660 290 1660 490 {}
N 1660 550 1660 920 {}
N 1720 0 1720 94 {}
N 1720 260 1720 354 {}
N 1720 520 1720 614 {}
N -2220 -140 1855 -140 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -900 0 -840 0 {}
N -800 0 -740 0 {}
N -525 0 -465 0 {}
N -425 0 -365 0 {}
N -160 0 -100 0 {}
N -60 0 -30 0 {}
N 20 0 80 0 {}
N 120 0 150 0 {}
N 200 0 260 0 {}
N 300 0 360 0 {}
N 540 0 600 0 {}
N 640 0 940 0 {}
N 980 0 1040 0 {}
N 1220 0 1280 0 {}
N 1320 0 1380 0 {}
N 1560 0 1620 0 {}
N 1660 0 1720 0 {}
N -1210 70 -1170 70 {}
N 1280 70 1320 70 {}
N -1910 260 -1850 260 {}
N -1790 260 -1760 260 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1140 260 {}
N -1090 260 -1030 260 {}
N -990 260 -960 260 {}
N -900 260 -840 260 {}
N -800 260 -740 260 {}
N -525 260 -465 260 {}
N -425 260 -395 260 {}
N -345 260 -285 260 {}
N -245 260 -215 260 {}
N -160 260 -100 260 {}
N -60 260 0 260 {}
N 200 260 260 260 {}
N 300 260 360 260 {}
N 540 260 600 260 {}
N 640 260 700 260 {}
N 880 260 940 260 {}
N 980 260 1040 260 {}
N 1220 260 1280 260 {}
N 1320 260 1380 260 {}
N 1560 260 1620 260 {}
N 1660 260 1720 260 {}
N -1210 320 -1030 320 {}
N -465 320 -285 320 {}
N 940 450 980 450 {}
N -840 460 -655 460 {}
N -1270 520 -1210 520 {}
N -1170 520 -1110 520 {}
N -900 520 -840 520 {}
N -800 520 -770 520 {}
N -715 520 -655 520 {}
N -615 520 -585 520 {}
N -525 520 -465 520 {}
N -425 520 -365 520 {}
N -160 520 -100 520 {}
N -60 520 0 520 {}
N 200 520 260 520 {}
N 300 520 360 520 {}
N 600 520 660 520 {}
N 720 520 750 520 {}
N 980 520 1040 520 {}
N 1220 520 1280 520 {}
N 1320 520 1380 520 {}
N 1560 520 1620 520 {}
N 1660 520 1720 520 {}
N -160 780 -100 780 {}
N -60 780 0 780 {}
N 200 780 260 780 {}
N 300 780 360 780 {}
N -2220 920 1855 920 {}
C {devices/lab_wire.sym} -2220 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -2220 920 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -60 60 2 0 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 120 60 2 0 {name=l4 lab=VB1}
C {devices/lab_wire.sym} 360 0 0 1 {name=l5 lab=VB1}
C {devices/lab_wire.sym} 600 350 2 0 {name=l6 lab=VB1}
C {devices/lab_wire.sym} 700 0 0 1 {name=l7 lab=VB1}
C {devices/lab_wire.sym} 1560 0 0 0 {name=l8 lab=VB1}
C {devices/lab_wire.sym} 0 260 0 1 {name=l9 lab=VB2}
C {devices/lab_wire.sym} 360 260 0 1 {name=l10 lab=VB2}
C {devices/lab_wire.sym} 700 260 0 1 {name=l11 lab=VB2}
C {devices/lab_wire.sym} 880 260 0 0 {name=l12 lab=VB2}
C {devices/lab_wire.sym} 1220 0 0 0 {name=l13 lab=VB2}
C {devices/lab_wire.sym} 1560 260 0 0 {name=l14 lab=VB2}
C {devices/lab_wire.sym} -1170 260 0 0 {name=l15 lab=VB3}
C {devices/lab_wire.sym} -740 260 0 1 {name=l16 lab=VB3}
C {devices/lab_wire.sym} -425 260 0 0 {name=l17 lab=VB3}
C {devices/lab_wire.sym} 0 520 0 1 {name=l18 lab=VB3}
C {devices/lab_wire.sym} 360 520 0 1 {name=l19 lab=VB3}
C {devices/lab_wire.sym} 980 350 2 0 {name=l20 lab=VB3}
C {devices/lab_wire.sym} 1220 260 0 0 {name=l21 lab=VB3}
C {devices/lab_wire.sym} -1110 520 0 1 {name=l22 lab=VB4}
C {devices/lab_wire.sym} -800 580 2 0 {name=l23 lab=VB4}
C {devices/lab_wire.sym} -365 520 0 1 {name=l24 lab=VB4}
C {devices/lab_wire.sym} -100 350 2 0 {name=l25 lab=VB4}
C {devices/lab_wire.sym} 0 780 0 1 {name=l26 lab=VB4}
C {devices/lab_wire.sym} 360 780 0 1 {name=l27 lab=VB4}
C {devices/lab_wire.sym} 1220 520 0 0 {name=l28 lab=VB4}
C {devices/lab_wire.sym} -990 320 2 0 {name=l29 lab=VINN}
C {devices/lab_wire.sym} -245 320 2 0 {name=l30 lab=VINP}
C {devices/lab_wire.sym} -1910 260 0 0 {name=l31 lab=VOUT}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l32 lab=VOUT}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l33 lab=VOUTN}
C {devices/lab_wire.sym} -365 0 0 1 {name=l34 lab=VOUTN}
C {devices/lab_wire.sym} -1790 320 2 0 {name=l35 lab=VOUTP}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l36 lab=VOUTP}
C {devices/lab_wire.sym} -740 0 0 1 {name=l37 lab=VOUTP}
C {devices/lab_wire.sym} -465 90 2 0 {name=l38 lab=VOUTP}
C {devices/lab_wire.sym} -465 170 0 1 {name=l39 lab=VOUTP}
C {devices/lab_wire.sym} -840 90 2 0 {name=l40 lab=net043}
C {devices/lab_wire.sym} -840 170 0 1 {name=l41 lab=net043}
C {devices/lab_wire.sym} -615 580 2 0 {name=l42 lab=net043}
C {devices/lab_wire.sym} 1560 520 0 0 {name=l43 lab=net043}
C {devices/lab_wire.sym} 1660 90 2 0 {name=l44 lab=net049}
C {devices/lab_wire.sym} -465 350 2 0 {name=l45 lab=net063}
C {devices/lab_wire.sym} -840 350 2 0 {name=l46 lab=net1}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l47 lab=net10}
C {devices/lab_wire.sym} 720 580 2 0 {name=l48 lab=net10}
C {devices/lab_wire.sym} 1660 350 2 0 {name=l49 lab=net10}
C {devices/lab_wire.sym} 600 90 2 0 {name=l50 lab=net2}
C {devices/lab_wire.sym} -100 90 2 0 {name=l51 lab=net3}
C {devices/lab_wire.sym} -100 170 0 1 {name=l52 lab=net3}
C {devices/lab_wire.sym} -1030 170 0 1 {name=l53 lab=net31}
C {devices/lab_wire.sym} -285 170 0 1 {name=l54 lab=net31}
C {devices/lab_wire.sym} 80 90 2 0 {name=l55 lab=net31}
C {devices/lab_wire.sym} 600 520 0 0 {name=l56 lab=net4}
C {devices/lab_wire.sym} 850 690 0 1 {name=l57 lab=net4}
C {devices/lab_wire.sym} -100 610 2 0 {name=l58 lab=net54}
C {devices/lab_wire.sym} 260 610 2 0 {name=l59 lab=net56}
C {devices/lab_wire.sym} 260 90 2 0 {name=l60 lab=net6}
C {devices/lab_wire.sym} 260 350 2 0 {name=l61 lab=net7}
C {devices/lab_wire.sym} 980 90 2 0 {name=l62 lab=net8}
C {devices/lab_wire.sym} 1320 350 2 0 {name=l63 lab=net9}
C {devices/lab_wire.sym} -1090 354 2 0 {name=l64 lab=net31}
C {devices/lab_wire.sym} -345 354 2 0 {name=l65 lab=net31}
C {devices/lab_wire.sym} 540 94 2 0 {name=l66 lab=vdd}
C {devices/lab_wire.sym} -160 94 2 0 {name=l67 lab=vdd}
C {devices/lab_wire.sym} -900 94 2 0 {name=l68 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l69 lab=vdd}
C {devices/lab_wire.sym} 200 94 2 0 {name=l70 lab=vdd}
C {devices/lab_wire.sym} 1040 94 2 0 {name=l71 lab=vdd}
C {devices/lab_wire.sym} 20 94 2 0 {name=l72 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l73 lab=vdd}
C {devices/lab_wire.sym} 540 354 2 0 {name=l74 lab=vdd}
C {devices/lab_wire.sym} -160 354 2 0 {name=l75 lab=vdd}
C {devices/lab_wire.sym} -525 94 2 0 {name=l76 lab=vdd}
C {devices/lab_wire.sym} 200 354 2 0 {name=l77 lab=vdd}
C {devices/lab_wire.sym} 1040 354 2 0 {name=l78 lab=vdd}
C {devices/lab_wire.sym} 1380 94 2 0 {name=l79 lab=vdd}
C {devices/lab_wire.sym} 1720 354 2 0 {name=l80 lab=vdd}
C {devices/lab_wire.sym} 1720 94 2 0 {name=l81 lab=vdd}
C {devices/lab_wire.sym} -160 614 2 0 {name=l82 lab=vss}
C {devices/lab_wire.sym} 200 614 2 0 {name=l83 lab=vss}
C {devices/lab_wire.sym} 1040 614 2 0 {name=l84 lab=vss}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l85 lab=vss}
C {devices/lab_wire.sym} -525 354 2 0 {name=l86 lab=vss}
C {devices/lab_wire.sym} -160 874 2 0 {name=l87 lab=vss}
C {devices/lab_wire.sym} 200 874 2 0 {name=l88 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l89 lab=vss}
C {devices/lab_wire.sym} -525 614 2 0 {name=l90 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l91 lab=vss}
C {devices/lab_wire.sym} 1380 354 2 0 {name=l92 lab=vss}
C {devices/lab_wire.sym} 1380 614 2 0 {name=l93 lab=vss}
C {devices/lab_wire.sym} -900 354 2 0 {name=l94 lab=vss}
C {devices/lab_wire.sym} -900 614 2 0 {name=l95 lab=vss}
C {devices/lab_wire.sym} 1720 614 2 0 {name=l96 lab=vss}
C {devices/lab_wire.sym} -715 614 2 0 {name=l97 lab=vss}
C {devices/lab_wire.sym} -2160 690 0 1 {name=l98 lab=VB1}
C {devices/lab_wire.sym} -2160 870 2 0 {name=l99 lab=vss}
C {devices/ipin.sym} -2360 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -2360 380 0 0 {name=p1 lab=VINP}
B 8 -276 182 1496 858 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror (2 outputs) [alt: cm.nmos.low_voltage_cascode, cm.nmos.low_voltage_cascode]} -276 164 0 0 0.3 0.3 {layer=8}
B 10 -1378 -78 -375 78 {fill=0}
T {PMOS Simple Current Mirror} -1378 -96 0 0 0.3 0.3 {layer=10}
B 12 -276 -78 1836 338 {fill=0}
T {PMOS Improved High Swing Cascode Current Mirror (4 outputs) [alt: cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode, cm.pmos.low_voltage_cascode]} -276 -96 0 0 0.3 0.3 {layer=12}
B 21 -1198 182 -195 338 {fill=0}
T {PMOS Differential Pair} -1198 164 0 0 0.3 0.3 {layer=21}
