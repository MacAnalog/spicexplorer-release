v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_012_peng_tcfc} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 795 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1580 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} 1010 0 0 0 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -640 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1795 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} 2135 0 0 0 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -640 520 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -300 520 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 570 520 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} -1085 260 0 1 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -640 780 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -300 780 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1530 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -300 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} -1085 520 0 1 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 2135 260 0 0 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 570 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 400 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1010 260 0 0 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} -640 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} -1085 0 0 1 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} -300 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 570 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 40 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 40 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 40 0 0 0 {name=M65 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 1350 260 0 0 {name=M66 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm66_w l=x_dut_xm66_l m=x_dut_xm66_m}
C {devices/sg13_lv_nmos_np.sym} 1350 520 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 1350 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 1795 260 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_pmos_np.sym} -1310 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} -870 260 0 1 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 690 -1915 750 {}
N -1915 810 -1915 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1610 520 -1610 614 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 490 {}
N -1550 550 -1550 920 {}
N -1510 0 -1510 70 {}
N -1390 260 -1390 354 {}
N -1330 170 -1330 230 {}
N -1330 290 -1330 320 {}
N -1165 0 -1165 94 {}
N -1165 260 -1165 354 {}
N -1165 520 -1165 614 {}
N -1105 -140 -1105 -30 {}
N -1105 30 -1105 90 {}
N -1105 170 -1105 230 {}
N -1105 290 -1105 490 {}
N -1105 550 -1105 920 {}
N -1095 460 -1095 520 {}
N -1065 0 -1065 60 {}
N -950 260 -950 354 {}
N -890 170 -890 230 {}
N -890 290 -890 320 {}
N -720 0 -720 94 {}
N -720 260 -720 354 {}
N -720 520 -720 614 {}
N -720 780 -720 874 {}
N -660 -140 -660 -30 {}
N -660 30 -660 90 {}
N -660 170 -660 230 {}
N -660 290 -660 490 {}
N -660 550 -660 750 {}
N -660 810 -660 920 {}
N -620 400 -620 520 {}
N -590 -60 -590 0 {}
N -590 200 -590 260 {}
N -590 780 -590 840 {}
N -380 60 -380 230 {}
N -380 260 -380 354 {}
N -380 520 -380 614 {}
N -380 780 -380 874 {}
N -320 -140 -320 -30 {}
N -320 30 -320 90 {}
N -320 290 -320 490 {}
N -320 550 -320 750 {}
N -320 810 -320 920 {}
N -280 200 -280 260 {}
N -250 -60 -250 0 {}
N -250 200 -250 520 {}
N -250 780 -250 840 {}
N -10 200 -10 260 {}
N -10 260 -10 380 {}
N 0 60 0 230 {}
N 20 0 20 70 {}
N 50 520 50 780 {}
N 60 -140 60 -30 {}
N 60 30 60 70 {}
N 60 290 60 490 {}
N 60 550 60 920 {}
N 120 0 120 94 {}
N 120 260 120 354 {}
N 120 520 120 614 {}
N 320 0 320 94 {}
N 380 -140 380 -30 {}
N 380 30 380 90 {}
N 520 -60 520 0 {}
N 550 450 550 520 {}
N 580 230 580 260 {}
N 590 -140 590 -30 {}
N 590 30 590 90 {}
N 590 290 590 490 {}
N 590 550 590 920 {}
N 650 60 650 230 {}
N 650 260 650 354 {}
N 650 520 650 614 {}
N 825 260 825 320 {}
N 960 -60 960 0 {}
N 1030 -140 1030 -30 {}
N 1030 30 1030 230 {}
N 1030 290 1030 350 {}
N 1090 0 1090 94 {}
N 1090 260 1090 354 {}
N 1370 -140 1370 -30 {}
N 1370 30 1370 230 {}
N 1370 290 1370 490 {}
N 1370 550 1370 920 {}
N 1430 0 1430 94 {}
N 1430 260 1430 354 {}
N 1430 520 1430 614 {}
N 1580 200 1580 230 {}
N 1580 290 1580 350 {}
N 1775 -60 1775 0 {}
N 1775 190 1775 260 {}
N 1815 -140 1815 -30 {}
N 1815 30 1815 230 {}
N 1815 290 1815 920 {}
N 1875 0 1875 94 {}
N 1875 260 1875 354 {}
N 2155 -140 2155 -30 {}
N 2155 30 2155 230 {}
N 2155 290 2155 920 {}
N 2215 0 2215 94 {}
N 2215 260 2215 354 {}
N -2030 -140 2635 -140 {}
N -590 -60 -250 -60 {}
N 520 -60 960 -60 {}
N -1610 0 -1550 0 {}
N -1165 0 -1105 0 {}
N -1065 0 -1035 0 {}
N -720 0 -660 0 {}
N -620 0 -560 0 {}
N -280 0 -250 0 {}
N -40 0 20 0 {}
N 60 0 120 0 {}
N 320 0 380 0 {}
N 420 0 550 0 {}
N 960 0 990 0 {}
N 1030 0 1090 0 {}
N 1270 0 1330 0 {}
N 1370 0 1430 0 {}
N 1745 0 1775 0 {}
N 1815 0 1875 0 {}
N 2055 0 2115 0 {}
N 2155 0 2215 0 {}
N -380 60 -320 60 {}
N 0 60 60 60 {}
N 590 60 650 60 {}
N -1550 70 -1510 70 {}
N 20 70 60 70 {}
N 1775 190 1815 190 {}
N -590 200 -280 200 {}
N -250 200 -10 200 {}
N 1370 200 1580 200 {}
N -380 230 -320 230 {}
N 0 230 580 230 {}
N 590 230 650 230 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -1390 260 -1330 260 {}
N -1290 260 -1260 260 {}
N -1165 260 -1105 260 {}
N -1065 260 -1005 260 {}
N -950 260 -890 260 {}
N -850 260 -820 260 {}
N -720 260 -660 260 {}
N -620 260 -560 260 {}
N -380 260 -320 260 {}
N -40 260 20 260 {}
N 60 260 120 260 {}
N 520 260 580 260 {}
N 590 260 650 260 {}
N 705 260 765 260 {}
N 825 260 855 260 {}
N 930 260 990 260 {}
N 1030 260 1090 260 {}
N 1270 260 1330 260 {}
N 1370 260 1430 260 {}
N 1815 260 1875 260 {}
N 2055 260 2115 260 {}
N 2155 260 2215 260 {}
N -1550 320 -1330 320 {}
N -1105 320 -890 320 {}
N -10 380 590 380 {}
N -620 400 -250 400 {}
N 550 450 590 450 {}
N -1095 460 -660 460 {}
N -1610 520 -1550 520 {}
N -1510 520 -1450 520 {}
N -1165 520 -1105 520 {}
N -1095 520 -1035 520 {}
N -720 520 -660 520 {}
N -380 520 -320 520 {}
N -280 520 -250 520 {}
N -40 520 50 520 {}
N 60 520 120 520 {}
N 590 520 650 520 {}
N 1270 520 1330 520 {}
N 1370 520 1430 520 {}
N -720 780 -660 780 {}
N -620 780 -590 780 {}
N -380 780 -320 780 {}
N -280 780 50 780 {}
N -590 840 -250 840 {}
N -2030 920 2635 920 {}
C {devices/lab_wire.sym} -1550 350 2 0 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} -560 0 0 1 {name=l1 lab=VB1}
C {devices/lab_wire.sym} 480 0 0 1 {name=l2 lab=VB1}
C {devices/lab_wire.sym} 1030 350 2 0 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 1270 0 0 0 {name=l4 lab=VB1}
C {devices/lab_wire.sym} -560 260 0 1 {name=l5 lab=VB2}
C {devices/lab_wire.sym} -40 0 0 0 {name=l6 lab=VB2}
C {devices/lab_wire.sym} 930 260 0 0 {name=l7 lab=VB2}
C {devices/lab_wire.sym} 1270 260 0 0 {name=l8 lab=VB2}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} -1005 260 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -40 260 0 0 {name=l11 lab=VB3}
C {devices/lab_wire.sym} -1450 520 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -660 350 2 0 {name=l13 lab=VB4}
C {devices/lab_wire.sym} -40 520 0 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 705 260 0 0 {name=l15 lab=VOUT}
C {devices/lab_wire.sym} 1580 350 2 0 {name=l16 lab=VOUT}
C {devices/lab_wire.sym} 2155 90 2 0 {name=l17 lab=VOUT}
C {devices/lab_wire.sym} -1510 60 2 0 {name=l18 lab=VOUTN}
C {devices/lab_wire.sym} -1065 60 2 0 {name=l19 lab=VOUTN}
C {devices/lab_wire.sym} -1105 90 2 0 {name=l20 lab=VOUTP}
C {devices/lab_wire.sym} -1105 170 0 1 {name=l21 lab=VOUTP}
C {devices/lab_wire.sym} 825 320 2 0 {name=l22 lab=VOUTP}
C {devices/lab_wire.sym} 1775 -60 0 1 {name=l23 lab=VOUTP}
C {devices/lab_wire.sym} 2055 0 0 0 {name=l24 lab=VOUTP}
C {devices/lab_wire.sym} 1270 520 0 0 {name=l25 lab=net043}
C {devices/lab_wire.sym} 1815 90 2 0 {name=l26 lab=net043}
C {devices/lab_wire.sym} 1370 90 2 0 {name=l27 lab=net049}
C {devices/lab_wire.sym} -1105 350 2 0 {name=l28 lab=net063}
C {devices/lab_wire.sym} 1370 350 2 0 {name=l29 lab=net10}
C {devices/lab_wire.sym} 2055 260 0 0 {name=l30 lab=net10}
C {devices/lab_wire.sym} 1030 90 2 0 {name=l31 lab=net2}
C {devices/lab_wire.sym} -660 90 2 0 {name=l32 lab=net3}
C {devices/lab_wire.sym} -660 170 0 1 {name=l33 lab=net3}
C {devices/lab_wire.sym} -1330 170 0 1 {name=l34 lab=net31}
C {devices/lab_wire.sym} -890 170 0 1 {name=l35 lab=net31}
C {devices/lab_wire.sym} 380 90 2 0 {name=l36 lab=net31}
C {devices/lab_wire.sym} -660 610 2 0 {name=l37 lab=net54}
C {devices/lab_wire.sym} -320 610 2 0 {name=l38 lab=net56}
C {devices/lab_wire.sym} -320 90 2 0 {name=l39 lab=net6}
C {devices/lab_wire.sym} -320 350 2 0 {name=l40 lab=net7}
C {devices/lab_wire.sym} 590 90 2 0 {name=l41 lab=net8}
C {devices/lab_wire.sym} 60 350 2 0 {name=l42 lab=net9}
C {devices/lab_wire.sym} -1390 354 2 0 {name=l43 lab=net31}
C {devices/lab_wire.sym} -950 354 2 0 {name=l44 lab=net31}
C {devices/lab_wire.sym} 1090 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} -720 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} 1875 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} 2215 94 2 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} -320 0 0 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} 590 0 0 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} 320 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} 1090 354 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -720 354 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} -1165 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -380 354 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 650 354 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 120 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 1430 354 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 1430 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} -720 614 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} -380 614 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} 650 614 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} -1165 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -720 874 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} -380 874 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} -1610 614 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} -1165 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 2215 354 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 120 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} 120 614 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 1430 614 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} 1875 354 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} -1915 690 0 1 {name=l75 lab=VB1}
C {devices/lab_wire.sym} -1915 870 2 0 {name=l76 lab=vss}
C {devices/ipin.sym} -1260 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -820 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 920 0 0 {name=p3 lab=vss}
