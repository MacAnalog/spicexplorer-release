v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ia_004_fan_chopper_rrl} -7515 -1620 0 0 0.4 0.4 {}
C {blocks/cm_nmos_simple_1.sym} -7255 0 0 0 {name=xcm_nmos_simple_1}
C {blocks/dp_pmos_cascode_1.sym} -6815 0 0 0 {name=xdp_pmos_cascode_1}
C {blocks/tg_pair_cmos_rail_bulk_1.sym} -6345 0 0 0 {name=xtg_pair_cmos_rail_bulk_1}
C {blocks/tg_pair_cmos_rail_bulk_2.sym} -5845 0 0 0 {name=xtg_pair_cmos_rail_bulk_2}
C {blocks/dp_nmos_simple_1.sym} -5375 0 0 0 {name=xdp_nmos_simple_1}
C {blocks/tg_pair_cmos_rail_bulk_3.sym} -4905 0 0 0 {name=xtg_pair_cmos_rail_bulk_3}
C {blocks/dp_nmos_simple_2.sym} -4435 0 0 0 {name=xdp_nmos_simple_2}
C {blocks/tg_pair_cmos_rail_bulk_4.sym} -3965 0 0 0 {name=xtg_pair_cmos_rail_bulk_4}
C {blocks/tg_pair_cmos_rail_bulk_5.sym} -3465 0 0 0 {name=xtg_pair_cmos_rail_bulk_5}
C {blocks/tg_pair_cmos_rail_bulk_6.sym} -2965 0 0 0 {name=xtg_pair_cmos_rail_bulk_6}
C {blocks/tg_pair_cmos_rail_bulk_7.sym} -2465 0 0 0 {name=xtg_pair_cmos_rail_bulk_7}
C {blocks/tg_pair_cmos_rail_bulk_8.sym} -1965 0 0 0 {name=xtg_pair_cmos_rail_bulk_8}
C {blocks/tg_pair_cmos_rail_bulk_9.sym} -1465 0 0 0 {name=xtg_pair_cmos_rail_bulk_9}
C {blocks/tg_pair_cmos_rail_bulk_10.sym} -960 0 0 0 {name=xtg_pair_cmos_rail_bulk_10}
C {blocks/tg_pair_cmos_rail_bulk_11.sym} -450 0 0 0 {name=xtg_pair_cmos_rail_bulk_11}
C {blocks/dp_nmos_simple_3.sym} 25 0 0 0 {name=xdp_nmos_simple_3}
C {blocks/tg_pair_cmos_rail_bulk_12.sym} 500 0 0 0 {name=xtg_pair_cmos_rail_bulk_12}
C {blocks/dp_nmos_simple_4.sym} 975 0 0 0 {name=xdp_nmos_simple_4}
C {blocks/tg_pair_cmos_rail_bulk_13.sym} 1450 0 0 0 {name=xtg_pair_cmos_rail_bulk_13}
C {blocks/tg_pair_cmos_rail_bulk_14.sym} 1960 0 0 0 {name=xtg_pair_cmos_rail_bulk_14}
C {blocks/tg_pair_cmos_rail_bulk_15.sym} 2470 0 0 0 {name=xtg_pair_cmos_rail_bulk_15}
C {blocks/dp_pmos_simple_1.sym} 2945 0 0 0 {name=xdp_pmos_simple_1}
C {blocks/tg_pair_cmos_rail_bulk_16.sym} 3420 0 0 0 {name=xtg_pair_cmos_rail_bulk_16}
C {blocks/tg_pair_cmos_rail_bulk_17.sym} 3930 0 0 0 {name=xtg_pair_cmos_rail_bulk_17}
C {blocks/tg_pair_cmos_rail_bulk_18.sym} 4440 0 0 0 {name=xtg_pair_cmos_rail_bulk_18}
C {blocks/tg_pair_cmos_rail_bulk_19.sym} 4950 0 0 0 {name=xtg_pair_cmos_rail_bulk_19}
C {blocks/tg_pair_cmos_rail_bulk_20.sym} 5460 0 0 0 {name=xtg_pair_cmos_rail_bulk_20}
C {blocks/dp_pmos_simple_2.sym} 5935 0 0 0 {name=xdp_pmos_simple_2}
C {blocks/dp_pmos_simple_3.sym} 6375 0 0 0 {name=xdp_pmos_simple_3}
C {blocks/dp_pmos_simple_4.sym} 6815 0 0 0 {name=xdp_pmos_simple_4}
C {blocks/dp_pmos_simple_5.sym} 7255 0 0 0 {name=xdp_pmos_simple_5}
C {devices/capa_np.sym} -3960 340 0 0 {name=CAZ1_RRL value='x_dut_caz1_rrl_value'}
C {devices/capa_np.sym} -3740 340 0 0 {name=CAZ2_RRL value='x_dut_caz2_rrl_value'}
C {devices/capa_np.sym} -3520 340 0 0 {name=CFB1_MAIN value='x_dut_cfb1_main_value'}
C {devices/capa_np.sym} -3300 340 0 0 {name=CFB2_MAIN value='x_dut_cfb2_main_value'}
C {devices/capa_np.sym} -3080 340 0 0 {name=CIN1_MAIN value='x_dut_cin1_main_value'}
C {devices/capa_np.sym} -2860 340 0 0 {name=CIN2_MAIN value='x_dut_cin2_main_value'}
C {devices/capa_np.sym} -2640 340 0 0 {name=CINT1_RRL value='x_dut_cint1_rrl_value'}
C {devices/capa_np.sym} -2420 340 0 0 {name=CINT2_RRL value='x_dut_cint2_rrl_value'}
C {devices/capa_np.sym} -2200 340 0 0 {name=CIN_1_RRL value='cin_val_rrl'}
C {devices/capa_np.sym} -1980 340 0 0 {name=CIN_SERVO_CMFB value='cin_val_cmfb'}
C {devices/capa_np.sym} -1760 340 0 0 {name=CM1_MAIN value='x_dut_cm1_main_value'}
C {devices/capa_np.sym} -1540 340 0 0 {name=CM2_MAIN value='x_dut_cm2_main_value'}
C {devices/capa_np.sym} -1320 340 0 0 {name=COUT_1_RRL value='cout_val_rrl'}
C {devices/capa_np.sym} -1100 340 0 0 {name=COUT_SERVO_CMFB value='cout_val_cmfb'}
C {devices/capa_np.sym} -880 340 0 0 {name=CS1_RRL value='x_dut_cs1_rrl_value'}
C {devices/capa_np.sym} -660 340 0 0 {name=CS2_RRL value='x_dut_cs2_rrl_value'}
C {devices/res_np.sym} -440 340 0 0 {name=RB1_MAIN value='x_dut_rb1_main_value'}
C {devices/res_np.sym} -220 340 0 0 {name=RB2_MAIN value='x_dut_rb2_main_value'}
C {devices/res_np.sym} 0 340 0 0 {name=RIN_1_RRL value='rin_val_rrl'}
C {devices/res_np.sym} 220 340 0 0 {name=RIN_SERVO_CMFB value='rin_val_cmfb'}
C {devices/res_np.sym} 440 340 0 0 {name=RMN_CMFB value='x_dut_rmn_cmfb_value'}
C {devices/res_np.sym} 660 340 0 0 {name=RMP_CMFB value='x_dut_rmp_cmfb_value'}
C {devices/res_np.sym} 880 340 0 0 {name=ROUT_1_RRL value='rout_val_rrl'}
C {devices/res_np.sym} 1100 340 0 0 {name=ROUT_SERVO_CMFB value='rout_val_cmfb'}
C {devices/vsource_np.sym} -7475 340 0 0 {name=VB1_MAIN value="dc {vb1_main}"}
C {devices/vsource_np.sym} -7475 120 0 0 {name=VB1_RRL value="dc {vb1_rrl}"}
C {devices/vsource_np.sym} -7475 -100 0 0 {name=VB2_MAIN value="dc {vb2_main}"}
C {devices/vsource_np.sym} -7475 -320 0 0 {name=VB2_RRL value="dc {vb2_rrl}"}
C {devices/vsource_np.sym} -7475 -540 0 0 {name=VB3_MAIN value="dc {vb3_main}"}
C {devices/vsource_np.sym} -7475 -760 0 0 {name=VB3_RRL value="dc {vb3_rrl}"}
C {devices/vsource_np.sym} -7475 -980 0 0 {name=VB40 value="dc {vb40}"}
C {devices/vsource_np.sym} -7475 -1200 0 0 {name=VB4_RRL value="dc {vb4_rrl}"}
C {devices/vsource_np.sym} -7475 -1420 0 0 {name=VREFCM value="dc {vcm_ref}"}
C {devices/sg13_lv_pmos_np.sym} -880 -340 0 0 {name=M10_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_main_w l=x_dut_xm10_main_l m=x_dut_xm10_main_m}
C {devices/sg13_lv_pmos_np.sym} -660 -340 0 0 {name=M11_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_main_w l=x_dut_xm11_main_l m=x_dut_xm11_main_m}
C {devices/sg13_lv_nmos_np.sym} 1320 340 0 0 {name=M11_OPAMP_RRL model=sg13_lv_nmos spiceprefix=X w=x_dut_xm11_opamp_rrl_w l=x_dut_xm11_opamp_rrl_l m=x_dut_xm11_opamp_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 1540 340 0 0 {name=M12_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_main_w l=x_dut_xm12_main_l m=x_dut_xm12_main_m}
C {devices/sg13_lv_nmos_np.sym} 1760 340 0 0 {name=M12_OPAMP_RRL model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_opamp_rrl_w l=x_dut_xm12_opamp_rrl_l m=x_dut_xm12_opamp_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 1980 340 0 0 {name=M13_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_main_w l=x_dut_xm13_main_l m=x_dut_xm13_main_m}
C {devices/sg13_lv_nmos_np.sym} 2200 340 0 0 {name=M14_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_main_w l=x_dut_xm14_main_l m=x_dut_xm14_main_m}
C {devices/sg13_lv_nmos_np.sym} 2420 340 0 0 {name=M15_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_main_w l=x_dut_xm15_main_l m=x_dut_xm15_main_m}
C {devices/sg13_lv_nmos_np.sym} 2640 340 0 0 {name=M16_OPAMP_RRL model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_opamp_rrl_w l=x_dut_xm16_opamp_rrl_l m=x_dut_xm16_opamp_rrl_m}
C {devices/sg13_lv_pmos_np.sym} -440 -340 0 0 {name=M1_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_main_w l=x_dut_xm1_main_l m=x_dut_xm1_main_m}
C {devices/sg13_lv_pmos_np.sym} -220 -340 0 0 {name=M1_OPAMP_RRL model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_opamp_rrl_w l=x_dut_xm1_opamp_rrl_l m=x_dut_xm1_opamp_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 2860 340 0 0 {name=M1_S1_RRL model=sg13_lv_nmos spiceprefix=X w=x_dut_xm1_s1_rrl_w l=x_dut_xm1_s1_rrl_l m=x_dut_xm1_s1_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 3080 340 0 0 {name=M1_S2_RRL model=sg13_lv_nmos spiceprefix=X w=x_dut_xm1_s2_rrl_w l=x_dut_xm1_s2_rrl_l m=x_dut_xm1_s2_rrl_m}
C {devices/sg13_lv_pmos_np.sym} 3300 340 0 0 {name=M2_S1_RRL model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_s1_rrl_w l=x_dut_xm2_s1_rrl_l m=x_dut_xm2_s1_rrl_m}
C {devices/sg13_lv_pmos_np.sym} 3520 340 0 0 {name=M2_S2_RRL model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_s2_rrl_w l=x_dut_xm2_s2_rrl_l m=x_dut_xm2_s2_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 3740 340 0 0 {name=M4_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm4_main_w l=x_dut_xm4_main_l m=x_dut_xm4_main_m}
C {devices/sg13_lv_pmos_np.sym} 0 -340 0 0 {name=M4_OPAMP_RRL model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_opamp_rrl_w l=x_dut_xm4_opamp_rrl_l m=x_dut_xm4_opamp_rrl_m}
C {devices/sg13_lv_nmos_np.sym} 3960 340 0 0 {name=M5_MAIN model=sg13_lv_nmos spiceprefix=X w=x_dut_xm5_main_w l=x_dut_xm5_main_l m=x_dut_xm5_main_m}
C {devices/sg13_lv_pmos_np.sym} 220 -340 0 0 {name=M6_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_main_w l=x_dut_xm6_main_l m=x_dut_xm6_main_m}
C {devices/sg13_lv_pmos_np.sym} 440 -340 0 0 {name=M7_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_main_w l=x_dut_xm7_main_l m=x_dut_xm7_main_m}
C {devices/sg13_lv_pmos_np.sym} 660 -340 0 0 {name=M8_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_main_w l=x_dut_xm8_main_l m=x_dut_xm8_main_m}
C {devices/sg13_lv_pmos_np.sym} 880 -340 0 0 {name=M9_MAIN model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_main_w l=x_dut_xm9_main_l m=x_dut_xm9_main_m}
N -7145 -40 -7105 -40 {}
C {devices/lab_wire.sym} -7105 -40 0 1 {name=l0 lab=rrl__oa_cm_bias}
N -7145 0 -7105 0 {}
C {devices/lab_wire.sym} -7105 0 0 1 {name=l1 lab=rrl__oa_csrc_n}
N -7145 40 -7105 40 {}
C {devices/lab_wire.sym} -7105 40 0 1 {name=l2 lab=rrl__oa_csrc_p}
N -7255 100 -7255 140 {}
C {devices/lab_wire.sym} -7255 140 2 0 {name=l3 lab=vss}
N -6925 -40 -6965 -40 {}
C {devices/lab_wire.sym} -6965 -40 0 0 {name=l4 lab=rrl__oa_inn}
N -6925 0 -6965 0 {}
C {devices/lab_wire.sym} -6965 0 0 0 {name=l5 lab=rrl__oa_inp}
N -6925 40 -6965 40 {}
C {devices/lab_wire.sym} -6965 40 0 0 {name=l6 lab=rrl__vb1}
N -6705 -40 -6665 -40 {}
C {devices/lab_wire.sym} -6665 -40 0 1 {name=l7 lab=rrl__oa_outn}
N -6705 0 -6665 0 {}
C {devices/lab_wire.sym} -6665 0 0 1 {name=l8 lab=rrl__oa_outp}
N -6705 40 -6665 40 {}
C {devices/lab_wire.sym} -6665 40 0 1 {name=l9 lab=rrl__oa_tail}
N -6815 -100 -6815 -140 {}
C {devices/lab_wire.sym} -6815 -140 0 1 {name=l10 lab=vdd}
N -6485 -20 -6525 -20 {}
C {devices/lab_wire.sym} -6525 -20 0 0 {name=l11 lab=clk_chout}
N -6485 20 -6525 20 {}
C {devices/lab_wire.sym} -6525 20 0 0 {name=l12 lab=clk_chout_not}
N -6205 -20 -6165 -20 {}
C {devices/lab_wire.sym} -6165 -20 0 1 {name=l13 lab=main__g2_n}
N -6205 20 -6165 20 {}
C {devices/lab_wire.sym} -6165 20 0 1 {name=l14 lab=out1_n}
N -6345 -80 -6345 -120 {}
C {devices/lab_wire.sym} -6345 -120 0 1 {name=l15 lab=vdd}
N -6345 80 -6345 120 {}
C {devices/lab_wire.sym} -6345 120 2 0 {name=l16 lab=vss}
N -5985 -20 -6025 -20 {}
C {devices/lab_wire.sym} -6025 -20 0 0 {name=l17 lab=clk_chout}
N -5985 20 -6025 20 {}
C {devices/lab_wire.sym} -6025 20 0 0 {name=l18 lab=clk_chout_not}
N -5705 -20 -5665 -20 {}
C {devices/lab_wire.sym} -5665 -20 0 1 {name=l19 lab=main__g2_p}
N -5705 20 -5665 20 {}
C {devices/lab_wire.sym} -5665 20 0 1 {name=l20 lab=out1_p}
N -5845 -80 -5845 -120 {}
C {devices/lab_wire.sym} -5845 -120 0 1 {name=l21 lab=vdd}
N -5845 80 -5845 120 {}
C {devices/lab_wire.sym} -5845 120 2 0 {name=l22 lab=vss}
N -5485 -20 -5525 -20 {}
C {devices/lab_wire.sym} -5525 -20 0 0 {name=l23 lab=clk_chout}
N -5485 20 -5525 20 {}
C {devices/lab_wire.sym} -5525 20 0 0 {name=l24 lab=clk_chout_not}
N -5265 -40 -5225 -40 {}
C {devices/lab_wire.sym} -5225 -40 0 1 {name=l25 lab=rrl__sc_p}
N -5265 0 -5225 0 {}
C {devices/lab_wire.sym} -5225 0 0 1 {name=l26 lab=rrl__sum_n}
N -5265 40 -5225 40 {}
C {devices/lab_wire.sym} -5225 40 0 1 {name=l27 lab=rrl__sum_p}
N -5375 100 -5375 140 {}
C {devices/lab_wire.sym} -5375 140 2 0 {name=l28 lab=vss}
N -5045 -20 -5085 -20 {}
C {devices/lab_wire.sym} -5085 -20 0 0 {name=l29 lab=clk_chout}
N -5045 20 -5085 20 {}
C {devices/lab_wire.sym} -5085 20 0 0 {name=l30 lab=clk_chout_not}
N -4765 -20 -4725 -20 {}
C {devices/lab_wire.sym} -4725 -20 0 1 {name=l31 lab=rrl__sc_p}
N -4765 20 -4725 20 {}
C {devices/lab_wire.sym} -4725 20 0 1 {name=l32 lab=rrl__sum_p}
N -4905 -80 -4905 -120 {}
C {devices/lab_wire.sym} -4905 -120 0 1 {name=l33 lab=vdd}
N -4905 80 -4905 120 {}
C {devices/lab_wire.sym} -4905 120 2 0 {name=l34 lab=vss}
N -4545 -20 -4585 -20 {}
C {devices/lab_wire.sym} -4585 -20 0 0 {name=l35 lab=clk_chout}
N -4545 20 -4585 20 {}
C {devices/lab_wire.sym} -4585 20 0 0 {name=l36 lab=clk_chout_not}
N -4325 -40 -4285 -40 {}
C {devices/lab_wire.sym} -4285 -40 0 1 {name=l37 lab=rrl__sc_n}
N -4325 0 -4285 0 {}
C {devices/lab_wire.sym} -4285 0 0 1 {name=l38 lab=rrl__sum_n}
N -4325 40 -4285 40 {}
C {devices/lab_wire.sym} -4285 40 0 1 {name=l39 lab=rrl__sum_p}
N -4435 100 -4435 140 {}
C {devices/lab_wire.sym} -4435 140 2 0 {name=l40 lab=vss}
N -4105 -20 -4145 -20 {}
C {devices/lab_wire.sym} -4145 -20 0 0 {name=l41 lab=clk_chout}
N -4105 20 -4145 20 {}
C {devices/lab_wire.sym} -4145 20 0 0 {name=l42 lab=clk_chout_not}
N -3825 -20 -3785 -20 {}
C {devices/lab_wire.sym} -3785 -20 0 1 {name=l43 lab=rrl__sc_n}
N -3825 20 -3785 20 {}
C {devices/lab_wire.sym} -3785 20 0 1 {name=l44 lab=rrl__sum_n}
N -3965 -80 -3965 -120 {}
C {devices/lab_wire.sym} -3965 -120 0 1 {name=l45 lab=vdd}
N -3965 80 -3965 120 {}
C {devices/lab_wire.sym} -3965 120 2 0 {name=l46 lab=vss}
N -3605 -20 -3645 -20 {}
C {devices/lab_wire.sym} -3645 -20 0 0 {name=l47 lab=clk_chout}
N -3605 20 -3645 20 {}
C {devices/lab_wire.sym} -3645 20 0 0 {name=l48 lab=clk_chout_not}
N -3325 -20 -3285 -20 {}
C {devices/lab_wire.sym} -3285 -20 0 1 {name=l49 lab=rrl__sc_n}
N -3325 20 -3285 20 {}
C {devices/lab_wire.sym} -3285 20 0 1 {name=l50 lab=rrl__sum_p}
N -3465 -80 -3465 -120 {}
C {devices/lab_wire.sym} -3465 -120 0 1 {name=l51 lab=vdd}
N -3465 80 -3465 120 {}
C {devices/lab_wire.sym} -3465 120 2 0 {name=l52 lab=vss}
N -3105 -20 -3145 -20 {}
C {devices/lab_wire.sym} -3145 -20 0 0 {name=l53 lab=clk_chout}
N -3105 20 -3145 20 {}
C {devices/lab_wire.sym} -3145 20 0 0 {name=l54 lab=clk_chout_not}
N -2825 -20 -2785 -20 {}
C {devices/lab_wire.sym} -2785 -20 0 1 {name=l55 lab=rrl__sc_p}
N -2825 20 -2785 20 {}
C {devices/lab_wire.sym} -2785 20 0 1 {name=l56 lab=rrl__sum_n}
N -2965 -80 -2965 -120 {}
C {devices/lab_wire.sym} -2965 -120 0 1 {name=l57 lab=vdd}
N -2965 80 -2965 120 {}
C {devices/lab_wire.sym} -2965 120 2 0 {name=l58 lab=vss}
N -2605 -20 -2645 -20 {}
C {devices/lab_wire.sym} -2645 -20 0 0 {name=l59 lab=clk_phi_1}
N -2605 20 -2645 20 {}
C {devices/lab_wire.sym} -2645 20 0 0 {name=l60 lab=clk_phi_2}
N -2325 -20 -2285 -20 {}
C {devices/lab_wire.sym} -2285 -20 0 1 {name=l61 lab=rrl__oa_inp}
N -2325 20 -2285 20 {}
C {devices/lab_wire.sym} -2285 20 0 1 {name=l62 lab=rrl__oa_outn}
N -2465 -80 -2465 -120 {}
C {devices/lab_wire.sym} -2465 -120 0 1 {name=l63 lab=vdd}
N -2465 80 -2465 120 {}
C {devices/lab_wire.sym} -2465 120 2 0 {name=l64 lab=vss}
N -2105 -20 -2145 -20 {}
C {devices/lab_wire.sym} -2145 -20 0 0 {name=l65 lab=clk_phi_1}
N -2105 20 -2145 20 {}
C {devices/lab_wire.sym} -2145 20 0 0 {name=l66 lab=clk_phi_2}
N -1825 -20 -1785 -20 {}
C {devices/lab_wire.sym} -1785 -20 0 1 {name=l67 lab=rrl__oa_inn}
N -1825 20 -1785 20 {}
C {devices/lab_wire.sym} -1785 20 0 1 {name=l68 lab=rrl__oa_outp}
N -1965 -80 -1965 -120 {}
C {devices/lab_wire.sym} -1965 -120 0 1 {name=l69 lab=vdd}
N -1965 80 -1965 120 {}
C {devices/lab_wire.sym} -1965 120 2 0 {name=l70 lab=vss}
N -1605 -20 -1645 -20 {}
C {devices/lab_wire.sym} -1645 -20 0 0 {name=l71 lab=clk_phi_1}
N -1605 20 -1645 20 {}
C {devices/lab_wire.sym} -1645 20 0 0 {name=l72 lab=clk_phi_2}
N -1325 -20 -1285 -20 {}
C {devices/lab_wire.sym} -1285 -20 0 1 {name=l73 lab=rrl__int_p}
N -1325 20 -1285 20 {}
C {devices/lab_wire.sym} -1285 20 0 1 {name=l74 lab=rrl__oa_outn}
N -1465 -80 -1465 -120 {}
C {devices/lab_wire.sym} -1465 -120 0 1 {name=l75 lab=vdd}
N -1465 80 -1465 120 {}
C {devices/lab_wire.sym} -1465 120 2 0 {name=l76 lab=vss}
N -1105 -20 -1145 -20 {}
C {devices/lab_wire.sym} -1145 -20 0 0 {name=l77 lab=clk_phi_1}
N -1105 20 -1145 20 {}
C {devices/lab_wire.sym} -1145 20 0 0 {name=l78 lab=clk_phi_2}
N -815 -20 -775 -20 {}
C {devices/lab_wire.sym} -775 -20 0 1 {name=l79 lab=rrl__int_n}
N -815 20 -775 20 {}
C {devices/lab_wire.sym} -775 20 0 1 {name=l80 lab=rrl__oa_outp}
N -960 -80 -960 -120 {}
C {devices/lab_wire.sym} -960 -120 0 1 {name=l81 lab=vdd}
N -960 80 -960 120 {}
C {devices/lab_wire.sym} -960 120 2 0 {name=l82 lab=vss}
N -595 -20 -635 -20 {}
C {devices/lab_wire.sym} -635 -20 0 0 {name=l83 lab=clk_chfb}
N -595 20 -635 20 {}
C {devices/lab_wire.sym} -635 20 0 0 {name=l84 lab=clk_chfb_not}
N -305 -20 -265 -20 {}
C {devices/lab_wire.sym} -265 -20 0 1 {name=l85 lab=main__fbch_p}
N -305 20 -265 20 {}
C {devices/lab_wire.sym} -265 20 0 1 {name=l86 lab=voutp}
N -450 -80 -450 -120 {}
C {devices/lab_wire.sym} -450 -120 0 1 {name=l87 lab=vdd}
N -450 80 -450 120 {}
C {devices/lab_wire.sym} -450 120 2 0 {name=l88 lab=vss}
N -85 -20 -125 -20 {}
C {devices/lab_wire.sym} -125 -20 0 0 {name=l89 lab=clk_chfb}
N -85 20 -125 20 {}
C {devices/lab_wire.sym} -125 20 0 0 {name=l90 lab=clk_chfb_not}
N 135 -40 175 -40 {}
C {devices/lab_wire.sym} 175 -40 0 1 {name=l91 lab=main__fbch_n}
N 135 0 175 0 {}
C {devices/lab_wire.sym} 175 0 0 1 {name=l92 lab=main__fbch_p}
N 135 40 175 40 {}
C {devices/lab_wire.sym} 175 40 0 1 {name=l93 lab=voutp}
N 25 100 25 140 {}
C {devices/lab_wire.sym} 25 140 2 0 {name=l94 lab=vss}
N 355 -20 315 -20 {}
C {devices/lab_wire.sym} 315 -20 0 0 {name=l95 lab=clk_chfb}
N 355 20 315 20 {}
C {devices/lab_wire.sym} 315 20 0 0 {name=l96 lab=clk_chfb_not}
N 645 -20 685 -20 {}
C {devices/lab_wire.sym} 685 -20 0 1 {name=l97 lab=main__fbch_n}
N 645 20 685 20 {}
C {devices/lab_wire.sym} 685 20 0 1 {name=l98 lab=voutn}
N 500 -80 500 -120 {}
C {devices/lab_wire.sym} 500 -120 0 1 {name=l99 lab=vdd}
N 500 80 500 120 {}
C {devices/lab_wire.sym} 500 120 2 0 {name=l100 lab=vss}
N 865 -20 825 -20 {}
C {devices/lab_wire.sym} 825 -20 0 0 {name=l101 lab=clk_chfb}
N 865 20 825 20 {}
C {devices/lab_wire.sym} 825 20 0 0 {name=l102 lab=clk_chfb_not}
N 1085 -40 1125 -40 {}
C {devices/lab_wire.sym} 1125 -40 0 1 {name=l103 lab=main__fbch_n}
N 1085 0 1125 0 {}
C {devices/lab_wire.sym} 1125 0 0 1 {name=l104 lab=main__fbch_p}
N 1085 40 1125 40 {}
C {devices/lab_wire.sym} 1125 40 0 1 {name=l105 lab=voutn}
N 975 100 975 140 {}
C {devices/lab_wire.sym} 975 140 2 0 {name=l106 lab=vss}
N 1305 -20 1265 -20 {}
C {devices/lab_wire.sym} 1265 -20 0 0 {name=l107 lab=clk_chin}
N 1305 20 1265 20 {}
C {devices/lab_wire.sym} 1265 20 0 0 {name=l108 lab=clk_chin_not}
N 1595 -20 1635 -20 {}
C {devices/lab_wire.sym} 1635 -20 0 1 {name=l109 lab=main__inch_n}
N 1595 20 1635 20 {}
C {devices/lab_wire.sym} 1635 20 0 1 {name=l110 lab=vinn}
N 1450 -80 1450 -120 {}
C {devices/lab_wire.sym} 1450 -120 0 1 {name=l111 lab=vdd}
N 1450 80 1450 120 {}
C {devices/lab_wire.sym} 1450 120 2 0 {name=l112 lab=vss}
N 1815 -20 1775 -20 {}
C {devices/lab_wire.sym} 1775 -20 0 0 {name=l113 lab=clk_chin}
N 1815 20 1775 20 {}
C {devices/lab_wire.sym} 1775 20 0 0 {name=l114 lab=clk_chin_not}
N 2105 -20 2145 -20 {}
C {devices/lab_wire.sym} 2145 -20 0 1 {name=l115 lab=main__inch_p}
N 2105 20 2145 20 {}
C {devices/lab_wire.sym} 2145 20 0 1 {name=l116 lab=vinp}
N 1960 -80 1960 -120 {}
C {devices/lab_wire.sym} 1960 -120 0 1 {name=l117 lab=vdd}
N 1960 80 1960 120 {}
C {devices/lab_wire.sym} 1960 120 2 0 {name=l118 lab=vss}
N 2325 -20 2285 -20 {}
C {devices/lab_wire.sym} 2285 -20 0 0 {name=l119 lab=clk_chout}
N 2325 20 2285 20 {}
C {devices/lab_wire.sym} 2285 20 0 0 {name=l120 lab=clk_chout_not}
N 2615 -20 2655 -20 {}
C {devices/lab_wire.sym} 2655 -20 0 1 {name=l121 lab=main__g2_p}
N 2615 20 2655 20 {}
C {devices/lab_wire.sym} 2655 20 0 1 {name=l122 lab=out1_n}
N 2470 -80 2470 -120 {}
C {devices/lab_wire.sym} 2470 -120 0 1 {name=l123 lab=vdd}
N 2470 80 2470 120 {}
C {devices/lab_wire.sym} 2470 120 2 0 {name=l124 lab=vss}
N 2835 -20 2795 -20 {}
C {devices/lab_wire.sym} 2795 -20 0 0 {name=l125 lab=main__vsum_n}
N 2835 20 2795 20 {}
C {devices/lab_wire.sym} 2795 20 0 0 {name=l126 lab=main__vsum_p}
N 3055 -40 3095 -40 {}
C {devices/lab_wire.sym} 3095 -40 0 1 {name=l127 lab=main__fold_n}
N 3055 0 3095 0 {}
C {devices/lab_wire.sym} 3095 0 0 1 {name=l128 lab=main__fold_p}
N 3055 40 3095 40 {}
C {devices/lab_wire.sym} 3095 40 0 1 {name=l129 lab=main__tail}
N 2945 -100 2945 -140 {}
C {devices/lab_wire.sym} 2945 -140 0 1 {name=l130 lab=vdd}
N 3275 -20 3235 -20 {}
C {devices/lab_wire.sym} 3235 -20 0 0 {name=l131 lab=clk_chout}
N 3275 20 3235 20 {}
C {devices/lab_wire.sym} 3235 20 0 0 {name=l132 lab=clk_chout_not}
N 3565 -20 3605 -20 {}
C {devices/lab_wire.sym} 3605 -20 0 1 {name=l133 lab=main__g2_n}
N 3565 20 3605 20 {}
C {devices/lab_wire.sym} 3605 20 0 1 {name=l134 lab=out1_p}
N 3420 -80 3420 -120 {}
C {devices/lab_wire.sym} 3420 -120 0 1 {name=l135 lab=vdd}
N 3420 80 3420 120 {}
C {devices/lab_wire.sym} 3420 120 2 0 {name=l136 lab=vss}
N 3785 -20 3745 -20 {}
C {devices/lab_wire.sym} 3745 -20 0 0 {name=l137 lab=clk_chin}
N 3785 20 3745 20 {}
C {devices/lab_wire.sym} 3745 20 0 0 {name=l138 lab=clk_chin_not}
N 4075 -20 4115 -20 {}
C {devices/lab_wire.sym} 4115 -20 0 1 {name=l139 lab=main__inch_p}
N 4075 20 4115 20 {}
C {devices/lab_wire.sym} 4115 20 0 1 {name=l140 lab=vinn}
N 3930 -80 3930 -120 {}
C {devices/lab_wire.sym} 3930 -120 0 1 {name=l141 lab=vdd}
N 3930 80 3930 120 {}
C {devices/lab_wire.sym} 3930 120 2 0 {name=l142 lab=vss}
N 4295 -20 4255 -20 {}
C {devices/lab_wire.sym} 4255 -20 0 0 {name=l143 lab=clk_chin}
N 4295 20 4255 20 {}
C {devices/lab_wire.sym} 4255 20 0 0 {name=l144 lab=clk_chin_not}
N 4585 -20 4625 -20 {}
C {devices/lab_wire.sym} 4625 -20 0 1 {name=l145 lab=main__inch_n}
N 4585 20 4625 20 {}
C {devices/lab_wire.sym} 4625 20 0 1 {name=l146 lab=vinp}
N 4440 -80 4440 -120 {}
C {devices/lab_wire.sym} 4440 -120 0 1 {name=l147 lab=vdd}
N 4440 80 4440 120 {}
C {devices/lab_wire.sym} 4440 120 2 0 {name=l148 lab=vss}
N 4805 -20 4765 -20 {}
C {devices/lab_wire.sym} 4765 -20 0 0 {name=l149 lab=clk_chfb}
N 4805 20 4765 20 {}
C {devices/lab_wire.sym} 4765 20 0 0 {name=l150 lab=clk_chfb_not}
N 5095 -20 5135 -20 {}
C {devices/lab_wire.sym} 5135 -20 0 1 {name=l151 lab=main__fbch_p}
N 5095 20 5135 20 {}
C {devices/lab_wire.sym} 5135 20 0 1 {name=l152 lab=voutn}
N 4950 -80 4950 -120 {}
C {devices/lab_wire.sym} 4950 -120 0 1 {name=l153 lab=vdd}
N 4950 80 4950 120 {}
C {devices/lab_wire.sym} 4950 120 2 0 {name=l154 lab=vss}
N 5315 -20 5275 -20 {}
C {devices/lab_wire.sym} 5275 -20 0 0 {name=l155 lab=clk_chfb}
N 5315 20 5275 20 {}
C {devices/lab_wire.sym} 5275 20 0 0 {name=l156 lab=clk_chfb_not}
N 5605 -20 5645 -20 {}
C {devices/lab_wire.sym} 5645 -20 0 1 {name=l157 lab=main__fbch_n}
N 5605 20 5645 20 {}
C {devices/lab_wire.sym} 5645 20 0 1 {name=l158 lab=voutp}
N 5460 -80 5460 -120 {}
C {devices/lab_wire.sym} 5460 -120 0 1 {name=l159 lab=vdd}
N 5460 80 5460 120 {}
C {devices/lab_wire.sym} 5460 120 2 0 {name=l160 lab=vss}
N 5825 -20 5785 -20 {}
C {devices/lab_wire.sym} 5785 -20 0 0 {name=l161 lab=rrl__oa_outn}
N 5825 20 5785 20 {}
C {devices/lab_wire.sym} 5785 20 0 0 {name=l162 lab=rrl__vb4}
N 6045 -40 6085 -40 {}
C {devices/lab_wire.sym} 6085 -40 0 1 {name=l163 lab=rrl__oa_cm_bias}
N 6045 0 6085 0 {}
C {devices/lab_wire.sym} 6085 0 0 1 {name=l164 lab=rrl__oa_cm_sense}
N 6045 40 6085 40 {}
C {devices/lab_wire.sym} 6085 40 0 1 {name=l165 lab=rrl__oa_cm_tail}
N 5935 -100 5935 -140 {}
C {devices/lab_wire.sym} 5935 -140 0 1 {name=l166 lab=vdd}
N 6265 -20 6225 -20 {}
C {devices/lab_wire.sym} 6225 -20 0 0 {name=l167 lab=rrl__oa_outn}
N 6265 20 6225 20 {}
C {devices/lab_wire.sym} 6225 20 0 0 {name=l168 lab=rrl__vb4}
N 6485 -40 6525 -40 {}
C {devices/lab_wire.sym} 6525 -40 0 1 {name=l169 lab=rrl__oa_cm_bias}
N 6485 0 6525 0 {}
C {devices/lab_wire.sym} 6525 0 0 1 {name=l170 lab=rrl__oa_cm_sense}
N 6485 40 6525 40 {}
C {devices/lab_wire.sym} 6525 40 0 1 {name=l171 lab=rrl__oa_cm_tail}
N 6375 -100 6375 -140 {}
C {devices/lab_wire.sym} 6375 -140 0 1 {name=l172 lab=vdd}
N 6705 -20 6665 -20 {}
C {devices/lab_wire.sym} 6665 -20 0 0 {name=l173 lab=rrl__oa_outp}
N 6705 20 6665 20 {}
C {devices/lab_wire.sym} 6665 20 0 0 {name=l174 lab=rrl__vb4}
N 6925 -40 6965 -40 {}
C {devices/lab_wire.sym} 6965 -40 0 1 {name=l175 lab=rrl__oa_cm_bias}
N 6925 0 6965 0 {}
C {devices/lab_wire.sym} 6965 0 0 1 {name=l176 lab=rrl__oa_cm_sense}
N 6925 40 6965 40 {}
C {devices/lab_wire.sym} 6965 40 0 1 {name=l177 lab=rrl__oa_cm_tail}
N 6815 -100 6815 -140 {}
C {devices/lab_wire.sym} 6815 -140 0 1 {name=l178 lab=vdd}
N 7145 -20 7105 -20 {}
C {devices/lab_wire.sym} 7105 -20 0 0 {name=l179 lab=rrl__oa_outp}
N 7145 20 7105 20 {}
C {devices/lab_wire.sym} 7105 20 0 0 {name=l180 lab=rrl__vb4}
N 7365 -40 7405 -40 {}
C {devices/lab_wire.sym} 7405 -40 0 1 {name=l181 lab=rrl__oa_cm_bias}
N 7365 0 7405 0 {}
C {devices/lab_wire.sym} 7405 0 0 1 {name=l182 lab=rrl__oa_cm_sense}
N 7365 40 7405 40 {}
C {devices/lab_wire.sym} 7405 40 0 1 {name=l183 lab=rrl__oa_cm_tail}
N 7255 -100 7255 -140 {}
C {devices/lab_wire.sym} 7255 -140 0 1 {name=l184 lab=vdd}
N -3960 310 -3960 270 {}
C {devices/lab_wire.sym} -3960 270 0 1 {name=l185 lab=rrl__sum_p}
N -3960 370 -3960 410 {}
C {devices/lab_wire.sym} -3960 410 2 0 {name=l186 lab=rrl__oa_inp}
N -3740 310 -3740 270 {}
C {devices/lab_wire.sym} -3740 270 0 1 {name=l187 lab=rrl__sum_n}
N -3740 370 -3740 410 {}
C {devices/lab_wire.sym} -3740 410 2 0 {name=l188 lab=rrl__oa_inn}
N -3520 310 -3520 270 {}
C {devices/lab_wire.sym} -3520 270 0 1 {name=l189 lab=main__fbch_p}
N -3520 370 -3520 410 {}
C {devices/lab_wire.sym} -3520 410 2 0 {name=l190 lab=main__vsum_n}
N -3300 310 -3300 270 {}
C {devices/lab_wire.sym} -3300 270 0 1 {name=l191 lab=main__fbch_n}
N -3300 370 -3300 410 {}
C {devices/lab_wire.sym} -3300 410 2 0 {name=l192 lab=main__vsum_p}
N -3080 310 -3080 270 {}
C {devices/lab_wire.sym} -3080 270 0 1 {name=l193 lab=main__vsum_n}
N -3080 370 -3080 410 {}
C {devices/lab_wire.sym} -3080 410 2 0 {name=l194 lab=main__inch_n}
N -2860 310 -2860 270 {}
C {devices/lab_wire.sym} -2860 270 0 1 {name=l195 lab=main__vsum_p}
N -2860 370 -2860 410 {}
C {devices/lab_wire.sym} -2860 410 2 0 {name=l196 lab=main__inch_p}
N -2640 310 -2640 270 {}
C {devices/lab_wire.sym} -2640 270 0 1 {name=l197 lab=rrl__sum_p}
N -2640 370 -2640 410 {}
C {devices/lab_wire.sym} -2640 410 2 0 {name=l198 lab=rrl__int_p}
N -2420 310 -2420 270 {}
C {devices/lab_wire.sym} -2420 270 0 1 {name=l199 lab=rrl__sum_n}
N -2420 370 -2420 410 {}
C {devices/lab_wire.sym} -2420 410 2 0 {name=l200 lab=rrl__int_n}
N -2200 310 -2200 270 {}
C {devices/lab_wire.sym} -2200 270 0 1 {name=l201 lab=rrl__int_p}
N -2200 370 -2200 410 {}
C {devices/lab_wire.sym} -2200 410 2 0 {name=l202 lab=rrl__int_n}
N -1980 310 -1980 270 {}
C {devices/lab_wire.sym} -1980 270 0 1 {name=l203 lab=cmfb__cm_sense}
N -1980 370 -1980 410 {}
C {devices/lab_wire.sym} -1980 410 2 0 {name=l204 lab=vref_cm}
N -1760 310 -1760 270 {}
C {devices/lab_wire.sym} -1760 270 0 1 {name=l205 lab=main__g2_p}
N -1760 370 -1760 410 {}
C {devices/lab_wire.sym} -1760 410 2 0 {name=l206 lab=voutp}
N -1540 310 -1540 270 {}
C {devices/lab_wire.sym} -1540 270 0 1 {name=l207 lab=main__g2_n}
N -1540 370 -1540 410 {}
C {devices/lab_wire.sym} -1540 410 2 0 {name=l208 lab=voutn}
N -1320 310 -1320 270 {}
C {devices/lab_wire.sym} -1320 270 0 1 {name=l209 lab=out1_p}
N -1320 370 -1320 410 {}
C {devices/lab_wire.sym} -1320 410 2 0 {name=l210 lab=out1_n}
N -1100 310 -1100 270 {}
C {devices/lab_wire.sym} -1100 270 0 1 {name=l211 lab=vss}
N -1100 370 -1100 410 {}
C {devices/lab_wire.sym} -1100 410 2 0 {name=l212 lab=vcmfb_raw}
N -880 310 -880 270 {}
C {devices/lab_wire.sym} -880 270 0 1 {name=l213 lab=voutp}
N -880 370 -880 410 {}
C {devices/lab_wire.sym} -880 410 2 0 {name=l214 lab=rrl__sc_p}
N -660 310 -660 270 {}
C {devices/lab_wire.sym} -660 270 0 1 {name=l215 lab=voutn}
N -660 370 -660 410 {}
C {devices/lab_wire.sym} -660 410 2 0 {name=l216 lab=rrl__sc_n}
N -440 310 -440 270 {}
C {devices/lab_wire.sym} -440 270 0 1 {name=l217 lab=main__vsum_n}
N -440 370 -440 410 {}
C {devices/lab_wire.sym} -440 410 2 0 {name=l218 lab=vref}
N -220 310 -220 270 {}
C {devices/lab_wire.sym} -220 270 0 1 {name=l219 lab=main__vsum_p}
N -220 370 -220 410 {}
C {devices/lab_wire.sym} -220 410 2 0 {name=l220 lab=vref}
N 0 310 0 270 {}
C {devices/lab_wire.sym} 0 270 0 1 {name=l221 lab=rrl__int_p}
N 0 370 0 410 {}
C {devices/lab_wire.sym} 0 410 2 0 {name=l222 lab=rrl__int_n}
N 220 310 220 270 {}
C {devices/lab_wire.sym} 220 270 0 1 {name=l223 lab=cmfb__cm_sense}
N 220 370 220 410 {}
C {devices/lab_wire.sym} 220 410 2 0 {name=l224 lab=vref_cm}
N 440 310 440 270 {}
C {devices/lab_wire.sym} 440 270 0 1 {name=l225 lab=voutn}
N 440 370 440 410 {}
C {devices/lab_wire.sym} 440 410 2 0 {name=l226 lab=cmfb__cm_sense}
N 660 310 660 270 {}
C {devices/lab_wire.sym} 660 270 0 1 {name=l227 lab=cmfb__cm_sense}
N 660 370 660 410 {}
C {devices/lab_wire.sym} 660 410 2 0 {name=l228 lab=voutp}
N 880 310 880 270 {}
C {devices/lab_wire.sym} 880 270 0 1 {name=l229 lab=out1_p}
N 880 370 880 410 {}
C {devices/lab_wire.sym} 880 410 2 0 {name=l230 lab=out1_n}
N 1100 310 1100 270 {}
C {devices/lab_wire.sym} 1100 270 0 1 {name=l231 lab=vss}
N 1100 370 1100 410 {}
C {devices/lab_wire.sym} 1100 410 2 0 {name=l232 lab=vcmfb_raw}
N -7475 310 -7475 270 {}
C {devices/lab_wire.sym} -7475 270 0 1 {name=l233 lab=main__vb1}
N -7475 370 -7475 410 {}
C {devices/lab_wire.sym} -7475 410 2 0 {name=l234 lab=vss}
N -7475 90 -7475 50 {}
C {devices/lab_wire.sym} -7475 50 0 1 {name=l235 lab=rrl__vb1}
N -7475 150 -7475 190 {}
C {devices/lab_wire.sym} -7475 190 2 0 {name=l236 lab=vss}
N -7475 -130 -7475 -170 {}
C {devices/lab_wire.sym} -7475 -170 0 1 {name=l237 lab=main__vb2}
N -7475 -70 -7475 -30 {}
C {devices/lab_wire.sym} -7475 -30 2 0 {name=l238 lab=vss}
N -7475 -350 -7475 -390 {}
C {devices/lab_wire.sym} -7475 -390 0 1 {name=l239 lab=rrl__vb2}
N -7475 -290 -7475 -250 {}
C {devices/lab_wire.sym} -7475 -250 2 0 {name=l240 lab=vss}
N -7475 -570 -7475 -610 {}
C {devices/lab_wire.sym} -7475 -610 0 1 {name=l241 lab=main__vb3}
N -7475 -510 -7475 -470 {}
C {devices/lab_wire.sym} -7475 -470 2 0 {name=l242 lab=vss}
N -7475 -790 -7475 -830 {}
C {devices/lab_wire.sym} -7475 -830 0 1 {name=l243 lab=rrl__vb3}
N -7475 -730 -7475 -690 {}
C {devices/lab_wire.sym} -7475 -690 2 0 {name=l244 lab=vss}
N -7475 -1010 -7475 -1050 {}
C {devices/lab_wire.sym} -7475 -1050 0 1 {name=l245 lab=vb4_ctl}
N -7475 -950 -7475 -910 {}
C {devices/lab_wire.sym} -7475 -910 2 0 {name=l246 lab=vcmfb_raw}
N -7475 -1230 -7475 -1270 {}
C {devices/lab_wire.sym} -7475 -1270 0 1 {name=l247 lab=rrl__vb4}
N -7475 -1170 -7475 -1130 {}
C {devices/lab_wire.sym} -7475 -1130 2 0 {name=l248 lab=vss}
N -7475 -1450 -7475 -1490 {}
C {devices/lab_wire.sym} -7475 -1490 0 1 {name=l249 lab=vref_cm}
N -7475 -1390 -7475 -1350 {}
C {devices/lab_wire.sym} -7475 -1350 2 0 {name=l250 lab=vss}
N -860 -310 -860 -270 {}
C {devices/lab_wire.sym} -860 -270 2 0 {name=l251 lab=out1_n}
N -900 -340 -940 -340 {}
C {devices/lab_wire.sym} -940 -340 0 0 {name=l252 lab=main__vb3}
N -860 -370 -860 -410 {}
C {devices/lab_wire.sym} -860 -410 0 1 {name=l253 lab=main__casc_src_n}
N -860 -340 -820 -340 {}
C {devices/lab_wire.sym} -820 -340 0 1 {name=l254 lab=vdd}
N -640 -310 -640 -270 {}
C {devices/lab_wire.sym} -640 -270 2 0 {name=l255 lab=out1_p}
N -680 -340 -720 -340 {}
C {devices/lab_wire.sym} -720 -340 0 0 {name=l256 lab=main__vb3}
N -640 -370 -640 -410 {}
C {devices/lab_wire.sym} -640 -410 0 1 {name=l257 lab=main__casc_src_p}
N -640 -340 -600 -340 {}
C {devices/lab_wire.sym} -600 -340 0 1 {name=l258 lab=vdd}
N 1340 310 1340 270 {}
C {devices/lab_wire.sym} 1340 270 0 1 {name=l259 lab=rrl__oa_outn}
N 1300 340 1260 340 {}
C {devices/lab_wire.sym} 1260 340 0 0 {name=l260 lab=rrl__vb2}
N 1340 370 1340 410 {}
C {devices/lab_wire.sym} 1340 410 2 0 {name=l261 lab=rrl__oa_csrc_n}
N 1340 340 1380 340 {}
C {devices/lab_wire.sym} 1380 340 0 1 {name=l262 lab=vss}
N 1560 310 1560 270 {}
C {devices/lab_wire.sym} 1560 270 0 1 {name=l263 lab=out1_p}
N 1520 340 1480 340 {}
C {devices/lab_wire.sym} 1480 340 0 0 {name=l264 lab=main__vb2}
N 1560 370 1560 410 {}
C {devices/lab_wire.sym} 1560 410 2 0 {name=l265 lab=main__fold_p}
N 1560 340 1600 340 {}
C {devices/lab_wire.sym} 1600 340 0 1 {name=l266 lab=vss}
N 1780 310 1780 270 {}
C {devices/lab_wire.sym} 1780 270 0 1 {name=l267 lab=rrl__oa_outp}
N 1740 340 1700 340 {}
C {devices/lab_wire.sym} 1700 340 0 0 {name=l268 lab=rrl__vb2}
N 1780 370 1780 410 {}
C {devices/lab_wire.sym} 1780 410 2 0 {name=l269 lab=rrl__oa_csrc_p}
N 1780 340 1820 340 {}
C {devices/lab_wire.sym} 1820 340 0 1 {name=l270 lab=vss}
N 2000 310 2000 270 {}
C {devices/lab_wire.sym} 2000 270 0 1 {name=l271 lab=out1_n}
N 1960 340 1920 340 {}
C {devices/lab_wire.sym} 1920 340 0 0 {name=l272 lab=main__vb2}
N 2000 370 2000 410 {}
C {devices/lab_wire.sym} 2000 410 2 0 {name=l273 lab=main__fold_n}
N 2000 340 2040 340 {}
C {devices/lab_wire.sym} 2040 340 0 1 {name=l274 lab=vss}
N 2220 310 2220 270 {}
C {devices/lab_wire.sym} 2220 270 0 1 {name=l275 lab=voutp}
N 2180 340 2140 340 {}
C {devices/lab_wire.sym} 2140 340 0 0 {name=l276 lab=main__g2_p}
N 2220 370 2220 410 {}
C {devices/lab_wire.sym} 2220 410 2 0 {name=l277 lab=vss}
N 2220 340 2260 340 {}
C {devices/lab_wire.sym} 2260 340 0 1 {name=l278 lab=vss}
N 2440 310 2440 270 {}
C {devices/lab_wire.sym} 2440 270 0 1 {name=l279 lab=voutn}
N 2400 340 2360 340 {}
C {devices/lab_wire.sym} 2360 340 0 0 {name=l280 lab=main__g2_n}
N 2440 370 2440 410 {}
C {devices/lab_wire.sym} 2440 410 2 0 {name=l281 lab=vss}
N 2440 340 2480 340 {}
C {devices/lab_wire.sym} 2480 340 0 1 {name=l282 lab=vss}
N 2660 310 2660 270 {}
C {devices/lab_wire.sym} 2660 270 0 1 {name=l283 lab=rrl__oa_cm_sense}
N 2620 340 2580 340 {}
C {devices/lab_wire.sym} 2580 340 0 0 {name=l284 lab=rrl__oa_cm_sense}
N 2660 370 2660 410 {}
C {devices/lab_wire.sym} 2660 410 2 0 {name=l285 lab=vss}
N 2660 340 2700 340 {}
C {devices/lab_wire.sym} 2700 340 0 1 {name=l286 lab=vss}
N -420 -310 -420 -270 {}
C {devices/lab_wire.sym} -420 -270 2 0 {name=l287 lab=main__tail}
N -460 -340 -500 -340 {}
C {devices/lab_wire.sym} -500 -340 0 0 {name=l288 lab=vb4_ctl}
N -420 -370 -420 -410 {}
C {devices/lab_wire.sym} -420 -410 0 1 {name=l289 lab=vdd}
N -420 -340 -380 -340 {}
C {devices/lab_wire.sym} -380 -340 0 1 {name=l290 lab=vdd}
N -200 -310 -200 -270 {}
C {devices/lab_wire.sym} -200 -270 2 0 {name=l291 lab=rrl__oa_tail}
N -240 -340 -280 -340 {}
C {devices/lab_wire.sym} -280 -340 0 0 {name=l292 lab=rrl__vb3}
N -200 -370 -200 -410 {}
C {devices/lab_wire.sym} -200 -410 0 1 {name=l293 lab=vdd}
N -200 -340 -160 -340 {}
C {devices/lab_wire.sym} -160 -340 0 1 {name=l294 lab=vdd}
N 2880 310 2880 270 {}
C {devices/lab_wire.sym} 2880 270 0 1 {name=l295 lab=rrl__sc_n}
N 2840 340 2800 340 {}
C {devices/lab_wire.sym} 2800 340 0 0 {name=l296 lab=clk_phi_2}
N 2880 370 2880 410 {}
C {devices/lab_wire.sym} 2880 410 2 0 {name=l297 lab=vss}
N 2880 340 2920 340 {}
C {devices/lab_wire.sym} 2920 340 0 1 {name=l298 lab=vss}
N 3100 310 3100 270 {}
C {devices/lab_wire.sym} 3100 270 0 1 {name=l299 lab=rrl__sc_p}
N 3060 340 3020 340 {}
C {devices/lab_wire.sym} 3020 340 0 0 {name=l300 lab=clk_phi_2}
N 3100 370 3100 410 {}
C {devices/lab_wire.sym} 3100 410 2 0 {name=l301 lab=vss}
N 3100 340 3140 340 {}
C {devices/lab_wire.sym} 3140 340 0 1 {name=l302 lab=vss}
N 3320 370 3320 410 {}
C {devices/lab_wire.sym} 3320 410 2 0 {name=l303 lab=vss}
N 3280 340 3240 340 {}
C {devices/lab_wire.sym} 3240 340 0 0 {name=l304 lab=clk_phi_1}
N 3320 310 3320 270 {}
C {devices/lab_wire.sym} 3320 270 0 1 {name=l305 lab=rrl__sc_n}
N 3320 340 3360 340 {}
C {devices/lab_wire.sym} 3360 340 0 1 {name=l306 lab=vdd}
N 3540 370 3540 410 {}
C {devices/lab_wire.sym} 3540 410 2 0 {name=l307 lab=vss}
N 3500 340 3460 340 {}
C {devices/lab_wire.sym} 3460 340 0 0 {name=l308 lab=clk_phi_1}
N 3540 310 3540 270 {}
C {devices/lab_wire.sym} 3540 270 0 1 {name=l309 lab=rrl__sc_p}
N 3540 340 3580 340 {}
C {devices/lab_wire.sym} 3580 340 0 1 {name=l310 lab=vdd}
N 3760 310 3760 270 {}
C {devices/lab_wire.sym} 3760 270 0 1 {name=l311 lab=main__fold_p}
N 3720 340 3680 340 {}
C {devices/lab_wire.sym} 3680 340 0 0 {name=l312 lab=main__vb1}
N 3760 370 3760 410 {}
C {devices/lab_wire.sym} 3760 410 2 0 {name=l313 lab=vss}
N 3760 340 3800 340 {}
C {devices/lab_wire.sym} 3800 340 0 1 {name=l314 lab=vss}
N 20 -310 20 -270 {}
C {devices/lab_wire.sym} 20 -270 2 0 {name=l315 lab=rrl__oa_cm_tail}
N -20 -340 -60 -340 {}
C {devices/lab_wire.sym} -60 -340 0 0 {name=l316 lab=rrl__vb3}
N 20 -370 20 -410 {}
C {devices/lab_wire.sym} 20 -410 0 1 {name=l317 lab=vdd}
N 20 -340 60 -340 {}
C {devices/lab_wire.sym} 60 -340 0 1 {name=l318 lab=vdd}
N 3980 310 3980 270 {}
C {devices/lab_wire.sym} 3980 270 0 1 {name=l319 lab=main__fold_n}
N 3940 340 3900 340 {}
C {devices/lab_wire.sym} 3900 340 0 0 {name=l320 lab=main__vb1}
N 3980 370 3980 410 {}
C {devices/lab_wire.sym} 3980 410 2 0 {name=l321 lab=vss}
N 3980 340 4020 340 {}
C {devices/lab_wire.sym} 4020 340 0 1 {name=l322 lab=vss}
N 240 -310 240 -270 {}
C {devices/lab_wire.sym} 240 -270 2 0 {name=l323 lab=main__casc_src_n}
N 200 -340 160 -340 {}
C {devices/lab_wire.sym} 160 -340 0 0 {name=l324 lab=vb4_ctl}
N 240 -370 240 -410 {}
C {devices/lab_wire.sym} 240 -410 0 1 {name=l325 lab=vdd}
N 240 -340 280 -340 {}
C {devices/lab_wire.sym} 280 -340 0 1 {name=l326 lab=vdd}
N 460 -310 460 -270 {}
C {devices/lab_wire.sym} 460 -270 2 0 {name=l327 lab=main__casc_src_p}
N 420 -340 380 -340 {}
C {devices/lab_wire.sym} 380 -340 0 0 {name=l328 lab=vb4_ctl}
N 460 -370 460 -410 {}
C {devices/lab_wire.sym} 460 -410 0 1 {name=l329 lab=vdd}
N 460 -340 500 -340 {}
C {devices/lab_wire.sym} 500 -340 0 1 {name=l330 lab=vdd}
N 680 -310 680 -270 {}
C {devices/lab_wire.sym} 680 -270 2 0 {name=l331 lab=voutp}
N 640 -340 600 -340 {}
C {devices/lab_wire.sym} 600 -340 0 0 {name=l332 lab=vb4_ctl}
N 680 -370 680 -410 {}
C {devices/lab_wire.sym} 680 -410 0 1 {name=l333 lab=vdd}
N 680 -340 720 -340 {}
C {devices/lab_wire.sym} 720 -340 0 1 {name=l334 lab=vdd}
N 900 -310 900 -270 {}
C {devices/lab_wire.sym} 900 -270 2 0 {name=l335 lab=voutn}
N 860 -340 820 -340 {}
C {devices/lab_wire.sym} 820 -340 0 0 {name=l336 lab=vb4_ctl}
N 900 -370 900 -410 {}
C {devices/lab_wire.sym} 900 -410 0 1 {name=l337 lab=vdd}
N 900 -340 940 -340 {}
C {devices/lab_wire.sym} 940 -340 0 1 {name=l338 lab=vdd}
