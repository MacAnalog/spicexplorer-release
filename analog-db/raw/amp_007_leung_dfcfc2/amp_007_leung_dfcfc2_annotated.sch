v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_007_leung_dfcfc2} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1170 260 1 0 {name=C1 value='CAPACITOR_0'}
C {devices/capa_np.sym} 2060 260 1 0 {name=C2 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -755 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 265 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_pmos_np.sym} 605 0 0 0 {name=M12 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} -755 260 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} -415 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -75 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1390 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} 1835 260 0 0 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} -755 520 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -415 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} -415 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1390 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} 1835 520 0 0 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 265 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_nmos_np.sym} 945 260 0 0 {name=M24 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm24_w l=x_dut_xm24_l m=x_dut_xm24_m}
C {devices/sg13_lv_nmos_np.sym} 605 260 0 0 {name=M25 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm25_w l=x_dut_xm25_l m=x_dut_xm25_m}
C {devices/sg13_lv_pmos_np.sym} -75 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -970 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1390 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1835 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 945 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1615 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2345 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 430 -1915 490 {}
N -1915 550 -1915 610 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 660 {}
N -1510 190 -1510 260 {}
N -1270 0 -1270 94 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1170 0 -1170 70 {}
N -1050 0 -1050 94 {}
N -990 -140 -990 -30 {}
N -990 30 -990 90 {}
N -835 0 -835 94 {}
N -835 260 -835 354 {}
N -835 520 -835 614 {}
N -775 -140 -775 -30 {}
N -775 30 -775 90 {}
N -775 170 -775 230 {}
N -775 290 -775 490 {}
N -775 550 -775 660 {}
N -705 520 -705 580 {}
N -495 0 -495 94 {}
N -495 260 -495 354 {}
N -495 520 -495 614 {}
N -435 -140 -435 -30 {}
N -435 30 -435 90 {}
N -435 170 -435 230 {}
N -435 290 -435 490 {}
N -435 550 -435 660 {}
N -365 -60 -365 0 {}
N -365 520 -365 580 {}
N -155 30 -155 230 {}
N -155 260 -155 354 {}
N -95 -140 -95 -30 {}
N -95 30 -95 90 {}
N -95 190 -95 230 {}
N -95 290 -95 660 {}
N -55 190 -55 260 {}
N -25 -60 -25 0 {}
N 215 -60 215 0 {}
N 215 260 215 520 {}
N 225 30 225 230 {}
N 285 -140 285 -30 {}
N 285 30 285 90 {}
N 285 290 285 660 {}
N 345 0 345 94 {}
N 345 260 345 354 {}
N 555 -60 555 0 {}
N 625 -140 625 -30 {}
N 625 30 625 90 {}
N 625 170 625 230 {}
N 625 290 625 660 {}
N 685 0 685 94 {}
N 685 260 685 354 {}
N 965 -140 965 -30 {}
N 965 30 965 90 {}
N 965 170 965 230 {}
N 965 290 965 660 {}
N 1025 0 1025 94 {}
N 1025 260 1025 354 {}
N 1200 260 1200 320 {}
N 1340 520 1340 580 {}
N 1370 -60 1370 70 {}
N 1410 -140 1410 -30 {}
N 1410 30 1410 70 {}
N 1410 290 1410 490 {}
N 1410 550 1410 660 {}
N 1470 30 1470 230 {}
N 1470 260 1470 354 {}
N 1470 520 1470 614 {}
N 1635 170 1635 230 {}
N 1635 290 1635 320 {}
N 1695 260 1695 354 {}
N 1785 520 1785 580 {}
N 1815 -60 1815 0 {}
N 1855 -140 1855 -30 {}
N 1855 30 1855 90 {}
N 1855 170 1855 230 {}
N 1855 290 1855 490 {}
N 1855 550 1855 660 {}
N 1915 0 1915 94 {}
N 1915 260 1915 354 {}
N 1915 520 1915 614 {}
N 2365 170 2365 230 {}
N 2365 290 2365 320 {}
N 2425 260 2425 354 {}
N -2030 -140 2820 -140 {}
N -365 -60 -25 -60 {}
N 215 -60 555 -60 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -1170 0 -1110 0 {}
N -1050 0 -990 0 {}
N -950 0 -890 0 {}
N -835 0 -775 0 {}
N -735 0 -675 0 {}
N -495 0 -435 0 {}
N -395 0 -335 0 {}
N -55 0 -25 0 {}
N 185 0 245 0 {}
N 285 0 345 0 {}
N 555 0 585 0 {}
N 625 0 685 0 {}
N 865 0 925 0 {}
N 965 0 1025 0 {}
N 1785 0 1815 0 {}
N 1855 0 1915 0 {}
N -155 30 -95 30 {}
N 225 30 285 30 {}
N 1410 30 1470 30 {}
N -1210 70 -1170 70 {}
N 1370 70 1410 70 {}
N -1550 190 -1510 190 {}
N -95 190 -55 190 {}
N -155 230 -95 230 {}
N 225 230 285 230 {}
N 1410 230 1470 230 {}
N -1610 260 -1550 260 {}
N -835 260 -775 260 {}
N -735 260 -675 260 {}
N -495 260 -435 260 {}
N -395 260 -335 260 {}
N -155 260 -95 260 {}
N 185 260 245 260 {}
N 285 260 345 260 {}
N 525 260 585 260 {}
N 625 260 685 260 {}
N 865 260 925 260 {}
N 965 260 1025 260 {}
N 1080 260 1140 260 {}
N 1200 260 1230 260 {}
N 1310 260 1370 260 {}
N 1410 260 1470 260 {}
N 1505 260 1595 260 {}
N 1635 260 1695 260 {}
N 1755 260 1815 260 {}
N 1855 260 1915 260 {}
N 1970 260 2030 260 {}
N 2090 260 2120 260 {}
N 2235 260 2325 260 {}
N 2365 260 2425 260 {}
N 1410 320 1635 320 {}
N 1855 320 2365 320 {}
N -835 520 -775 520 {}
N -735 520 -705 520 {}
N -495 520 -435 520 {}
N -395 520 1370 520 {}
N 1410 520 1470 520 {}
N 1785 520 1815 520 {}
N 1855 520 1915 520 {}
N -705 580 -365 580 {}
N 1340 580 1785 580 {}
N -2030 660 2820 660 {}
C {devices/lab_wire.sym} -435 90 2 0 {name=l0 lab=DM_1}
C {devices/lab_wire.sym} -435 170 0 1 {name=l1 lab=DM_1}
C {devices/lab_wire.sym} 1410 350 2 0 {name=l2 lab=DM_2}
C {devices/lab_wire.sym} -675 260 0 1 {name=l3 lab=VB3}
C {devices/lab_wire.sym} -335 260 0 1 {name=l4 lab=VB3}
C {devices/lab_wire.sym} -95 90 2 0 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 1310 260 0 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 1755 260 0 0 {name=l7 lab=VB3}
C {devices/lab_wire.sym} -775 90 2 0 {name=l8 lab=VB4}
C {devices/lab_wire.sym} -775 170 0 1 {name=l9 lab=VB4}
C {devices/lab_wire.sym} 185 260 0 0 {name=l10 lab=VB4}
C {devices/lab_wire.sym} 625 90 2 0 {name=l11 lab=VOUT}
C {devices/lab_wire.sym} 625 170 0 1 {name=l12 lab=VOUT}
C {devices/lab_wire.sym} 1080 260 0 0 {name=l13 lab=VOUT}
C {devices/lab_wire.sym} 1370 -60 0 1 {name=l14 lab=VOUTN}
C {devices/lab_wire.sym} 1815 -60 0 1 {name=l15 lab=VOUTN}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l16 lab=net043}
C {devices/lab_wire.sym} 865 260 0 0 {name=l17 lab=net043}
C {devices/lab_wire.sym} 525 260 0 0 {name=l18 lab=net049}
C {devices/lab_wire.sym} 965 90 2 0 {name=l19 lab=net049}
C {devices/lab_wire.sym} 965 170 0 1 {name=l20 lab=net049}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l21 lab=net050}
C {devices/lab_wire.sym} 185 0 0 0 {name=l22 lab=net050}
C {devices/lab_wire.sym} 1200 320 2 0 {name=l23 lab=net050}
C {devices/lab_wire.sym} 1855 90 2 0 {name=l24 lab=net050}
C {devices/lab_wire.sym} 1855 170 0 1 {name=l25 lab=net050}
C {devices/lab_wire.sym} 2090 260 0 0 {name=l26 lab=net050}
C {devices/lab_wire.sym} 1855 350 2 0 {name=l27 lab=net063}
C {devices/lab_wire.sym} -1110 0 0 1 {name=l28 lab=net1}
C {devices/lab_wire.sym} -890 0 0 1 {name=l29 lab=net1}
C {devices/lab_wire.sym} -675 0 0 1 {name=l30 lab=net1}
C {devices/lab_wire.sym} -335 0 0 1 {name=l31 lab=net1}
C {devices/lab_wire.sym} 865 0 0 0 {name=l32 lab=net1}
C {devices/lab_wire.sym} 285 90 2 0 {name=l33 lab=net2}
C {devices/lab_wire.sym} 1970 260 0 0 {name=l34 lab=net2}
C {devices/lab_wire.sym} -990 90 2 0 {name=l35 lab=net31}
C {devices/lab_wire.sym} 1635 170 0 1 {name=l36 lab=net31}
C {devices/lab_wire.sym} 2365 170 0 1 {name=l37 lab=net31}
C {devices/lab_wire.sym} -775 350 2 0 {name=l38 lab=net54}
C {devices/lab_wire.sym} -435 350 2 0 {name=l39 lab=net56}
C {devices/lab_wire.sym} 1695 354 2 0 {name=l40 lab=net31}
C {devices/lab_wire.sym} 2425 354 2 0 {name=l41 lab=net31}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l42 lab=vdd}
C {devices/lab_wire.sym} -835 94 2 0 {name=l43 lab=vdd}
C {devices/lab_wire.sym} 345 94 2 0 {name=l44 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l45 lab=vdd}
C {devices/lab_wire.sym} 685 94 2 0 {name=l46 lab=vdd}
C {devices/lab_wire.sym} -495 94 2 0 {name=l47 lab=vdd}
C {devices/lab_wire.sym} -95 0 0 0 {name=l48 lab=vdd}
C {devices/lab_wire.sym} -1050 94 2 0 {name=l49 lab=vdd}
C {devices/lab_wire.sym} 1410 0 0 0 {name=l50 lab=vdd}
C {devices/lab_wire.sym} 1915 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} 1025 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} -835 354 2 0 {name=l53 lab=vss}
C {devices/lab_wire.sym} -495 354 2 0 {name=l54 lab=vss}
C {devices/lab_wire.sym} -155 354 2 0 {name=l55 lab=vss}
C {devices/lab_wire.sym} 1470 354 2 0 {name=l56 lab=vss}
C {devices/lab_wire.sym} 1915 354 2 0 {name=l57 lab=vss}
C {devices/lab_wire.sym} -835 614 2 0 {name=l58 lab=vss}
C {devices/lab_wire.sym} -495 614 2 0 {name=l59 lab=vss}
C {devices/lab_wire.sym} 1470 614 2 0 {name=l60 lab=vss}
C {devices/lab_wire.sym} 1915 614 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} 345 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} 1025 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} 685 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -1915 430 0 1 {name=l66 lab=net1}
C {devices/lab_wire.sym} -1915 610 2 0 {name=l67 lab=vss}
C {devices/ipin.sym} 1505 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 2235 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 660 0 0 {name=p3 lab=vss}
B 8 -1646 -78 1401 78 {fill=0}
T {PMOS Simple Current Mirror (5 outputs)} -1646 -96 0 0 0.3 0.3 {layer=8}
B 10 -1235 182 -5 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1235 164 0 0 0.3 0.3 {layer=10}
B 12 -2010 182 1425 338 {fill=0}
T {NMOS Simple Current Mirror} -2010 164 0 0 0.3 0.3 {layer=12}
B 21 1320 -78 2291 78 {fill=0}
T {PMOS Simple Current Mirror} 1320 -96 0 0 0.3 0.3 {layer=21}
B 15 1545 182 2801 338 {fill=0}
T {PMOS Differential Pair} 1545 164 0 0 0.3 0.3 {layer=15}
