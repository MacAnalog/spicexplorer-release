v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_009_leung_nmcnr} -1740 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} 1730 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1910 260 0 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1700 520 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 975 260 1 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -680 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -1020 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} -1360 0 0 1 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -340 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -1020 260 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 445 260 0 0 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 105 260 0 1 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} 1145 260 0 0 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 1515 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -1020 520 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 445 520 0 0 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} 1145 520 0 0 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 445 0 0 0 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 1515 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1360 260 0 1 {name=M21 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm21_w l=x_dut_xm21_l m=x_dut_xm21_m}
C {devices/sg13_lv_nmos_np.sym} 785 260 0 0 {name=M22 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm22_w l=x_dut_xm22_l m=x_dut_xm22_m}
C {devices/sg13_lv_nmos_np.sym} -340 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 105 0 0 1 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} -170 0 0 0 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} 1145 0 0 0 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} 1515 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 785 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_pmos_np.sym} 1335 260 0 0 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 2175 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1700 430 -1700 490 {}
N -1700 550 -1700 610 {}
N -1440 0 -1440 94 {}
N -1440 260 -1440 354 {}
N -1380 -140 -1380 -30 {}
N -1380 30 -1380 230 {}
N -1380 290 -1380 660 {}
N -1340 190 -1340 260 {}
N -1100 0 -1100 94 {}
N -1100 260 -1100 354 {}
N -1100 520 -1100 614 {}
N -1040 -140 -1040 -30 {}
N -1040 30 -1040 90 {}
N -1040 170 -1040 230 {}
N -1040 290 -1040 490 {}
N -1040 550 -1040 660 {}
N -760 0 -760 94 {}
N -700 -140 -700 -30 {}
N -700 30 -700 70 {}
N -660 0 -660 70 {}
N -420 0 -420 94 {}
N -420 260 -420 354 {}
N -360 -140 -360 -30 {}
N -360 30 -360 90 {}
N -360 170 -360 230 {}
N -360 290 -360 660 {}
N -320 0 -320 60 {}
N -150 -140 -150 -30 {}
N -150 30 -150 90 {}
N -90 0 -90 94 {}
N 25 0 25 94 {}
N 25 260 25 354 {}
N 85 -140 85 -30 {}
N 85 30 85 90 {}
N 85 170 85 230 {}
N 85 290 85 660 {}
N 125 190 125 260 {}
N 465 -140 465 -30 {}
N 465 30 465 90 {}
N 465 170 465 230 {}
N 465 290 465 490 {}
N 465 550 465 660 {}
N 525 0 525 94 {}
N 525 260 525 354 {}
N 525 520 525 614 {}
N 805 -140 805 -30 {}
N 805 30 805 90 {}
N 805 170 805 230 {}
N 805 290 805 660 {}
N 865 0 865 94 {}
N 865 260 865 354 {}
N 1005 260 1005 320 {}
N 1125 0 1125 70 {}
N 1125 200 1125 260 {}
N 1165 -140 1165 -30 {}
N 1165 30 1165 70 {}
N 1165 170 1165 230 {}
N 1165 290 1165 490 {}
N 1165 550 1165 660 {}
N 1225 0 1225 94 {}
N 1225 260 1225 354 {}
N 1225 520 1225 614 {}
N 1315 200 1315 260 {}
N 1355 170 1355 230 {}
N 1355 290 1355 320 {}
N 1415 260 1415 354 {}
N 1465 0 1465 60 {}
N 1495 200 1495 260 {}
N 1535 -140 1535 -30 {}
N 1535 30 1535 90 {}
N 1535 170 1535 230 {}
N 1535 290 1535 490 {}
N 1535 550 1535 660 {}
N 1595 0 1595 94 {}
N 1595 260 1595 354 {}
N 1595 520 1595 614 {}
N 1700 200 1700 260 {}
N 1760 260 1760 320 {}
N 1910 170 1910 230 {}
N 1910 290 1910 350 {}
N 2155 200 2155 260 {}
N 2195 170 2195 230 {}
N 2195 290 2195 350 {}
N 2255 260 2255 354 {}
N -1760 -140 2385 -140 {}
N -1440 0 -1380 0 {}
N -1340 0 -1280 0 {}
N -1100 0 -1040 0 {}
N -1000 0 -940 0 {}
N -760 0 -700 0 {}
N -660 0 -600 0 {}
N -420 0 -360 0 {}
N -320 0 -190 0 {}
N -150 0 -90 0 {}
N 25 0 85 0 {}
N 125 0 425 0 {}
N 465 0 525 0 {}
N 705 0 765 0 {}
N 805 0 865 0 {}
N 1065 0 1125 0 {}
N 1165 0 1225 0 {}
N 1435 0 1495 0 {}
N 1535 0 1595 0 {}
N -700 70 -660 70 {}
N 1125 70 1165 70 {}
N -1380 190 -1340 190 {}
N 85 190 125 190 {}
N -1440 260 -1380 260 {}
N -1100 260 -1040 260 {}
N -1000 260 -940 260 {}
N -420 260 -360 260 {}
N -320 260 -260 260 {}
N 25 260 85 260 {}
N 365 260 425 260 {}
N 465 260 525 260 {}
N 705 260 765 260 {}
N 805 260 865 260 {}
N 885 260 945 260 {}
N 1005 260 1035 260 {}
N 1095 260 1125 260 {}
N 1165 260 1225 260 {}
N 1285 260 1315 260 {}
N 1355 260 1415 260 {}
N 1465 260 1495 260 {}
N 1535 260 1595 260 {}
N 1670 260 1700 260 {}
N 1760 260 1910 260 {}
N 2125 260 2155 260 {}
N 2195 260 2255 260 {}
N 1165 320 1355 320 {}
N -1100 520 -1040 520 {}
N -1000 520 425 520 {}
N 465 520 525 520 {}
N 1065 520 1125 520 {}
N 1165 520 1225 520 {}
N 1435 520 1495 520 {}
N 1535 520 1595 520 {}
N -1760 660 2385 660 {}
C {devices/lab_wire.sym} -1760 -140 0 0 {name=l0 lab=vdd}
C {devices/lab_wire.sym} -1760 660 0 0 {name=l1 lab=vss}
C {devices/lab_wire.sym} 465 90 2 0 {name=l2 lab=DM_1}
C {devices/lab_wire.sym} 465 170 0 1 {name=l3 lab=DM_1}
C {devices/lab_wire.sym} 1165 350 2 0 {name=l4 lab=DM_2}
C {devices/lab_wire.sym} -940 260 0 1 {name=l5 lab=VB3}
C {devices/lab_wire.sym} 85 90 2 0 {name=l6 lab=VB3}
C {devices/lab_wire.sym} 85 170 0 1 {name=l7 lab=VB3}
C {devices/lab_wire.sym} 365 260 0 0 {name=l8 lab=VB3}
C {devices/lab_wire.sym} 1125 200 0 1 {name=l9 lab=VB3}
C {devices/lab_wire.sym} 1495 200 0 1 {name=l10 lab=VB3}
C {devices/lab_wire.sym} -1040 90 2 0 {name=l11 lab=VB4}
C {devices/lab_wire.sym} -1040 170 0 1 {name=l12 lab=VB4}
C {devices/lab_wire.sym} -940 520 0 1 {name=l13 lab=VB4}
C {devices/lab_wire.sym} 1065 520 0 0 {name=l14 lab=VB4}
C {devices/lab_wire.sym} 1435 520 0 0 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1315 200 0 1 {name=l16 lab=VINN}
C {devices/lab_wire.sym} 2155 200 0 1 {name=l17 lab=VINP}
C {devices/lab_wire.sym} -360 90 2 0 {name=l18 lab=VOUT}
C {devices/lab_wire.sym} -360 170 0 1 {name=l19 lab=VOUT}
C {devices/lab_wire.sym} 1005 320 2 0 {name=l20 lab=VOUT}
C {devices/lab_wire.sym} 1065 0 0 0 {name=l21 lab=VOUTN}
C {devices/lab_wire.sym} 1165 170 0 1 {name=l22 lab=VOUTN}
C {devices/lab_wire.sym} 1435 0 0 0 {name=l23 lab=VOUTN}
C {devices/lab_wire.sym} -940 0 0 1 {name=l24 lab=net013}
C {devices/lab_wire.sym} -600 0 0 1 {name=l25 lab=net013}
C {devices/lab_wire.sym} -320 60 2 0 {name=l26 lab=net013}
C {devices/lab_wire.sym} 185 0 0 1 {name=l27 lab=net013}
C {devices/lab_wire.sym} 705 0 0 0 {name=l28 lab=net013}
C {devices/lab_wire.sym} -1380 90 2 0 {name=l29 lab=net043}
C {devices/lab_wire.sym} 705 260 0 0 {name=l30 lab=net043}
C {devices/lab_wire.sym} 885 260 0 0 {name=l31 lab=net044}
C {devices/lab_wire.sym} 1760 320 2 0 {name=l32 lab=net044}
C {devices/lab_wire.sym} 1910 170 0 1 {name=l33 lab=net044}
C {devices/lab_wire.sym} -260 260 0 1 {name=l34 lab=net049}
C {devices/lab_wire.sym} 805 90 2 0 {name=l35 lab=net049}
C {devices/lab_wire.sym} 805 170 0 1 {name=l36 lab=net049}
C {devices/lab_wire.sym} 1910 350 2 0 {name=l37 lab=net049}
C {devices/lab_wire.sym} -1280 0 0 1 {name=l38 lab=net050}
C {devices/lab_wire.sym} 1535 90 2 0 {name=l39 lab=net050}
C {devices/lab_wire.sym} 1535 170 0 1 {name=l40 lab=net050}
C {devices/lab_wire.sym} 1700 200 0 1 {name=l41 lab=net050}
C {devices/lab_wire.sym} 1535 350 2 0 {name=l42 lab=net063}
C {devices/lab_wire.sym} 2195 350 2 0 {name=l43 lab=net063}
C {devices/lab_wire.sym} -150 90 2 0 {name=l44 lab=net31}
C {devices/lab_wire.sym} 1355 170 0 1 {name=l45 lab=net31}
C {devices/lab_wire.sym} 2195 170 0 1 {name=l46 lab=net31}
C {devices/lab_wire.sym} -1040 350 2 0 {name=l47 lab=net54}
C {devices/lab_wire.sym} 465 350 2 0 {name=l48 lab=net56}
C {devices/lab_wire.sym} 1415 354 2 0 {name=l49 lab=net31}
C {devices/lab_wire.sym} 2255 354 2 0 {name=l50 lab=net31}
C {devices/lab_wire.sym} -760 94 2 0 {name=l51 lab=vdd}
C {devices/lab_wire.sym} -1100 94 2 0 {name=l52 lab=vdd}
C {devices/lab_wire.sym} -1440 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -420 94 2 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} 525 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} 25 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} -90 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 1225 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 1595 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} 865 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} -1100 354 2 0 {name=l61 lab=vss}
C {devices/lab_wire.sym} 525 354 2 0 {name=l62 lab=vss}
C {devices/lab_wire.sym} 25 354 2 0 {name=l63 lab=vss}
C {devices/lab_wire.sym} 1225 354 2 0 {name=l64 lab=vss}
C {devices/lab_wire.sym} 1595 354 2 0 {name=l65 lab=vss}
C {devices/lab_wire.sym} -1100 614 2 0 {name=l66 lab=vss}
C {devices/lab_wire.sym} 525 614 2 0 {name=l67 lab=vss}
C {devices/lab_wire.sym} 1225 614 2 0 {name=l68 lab=vss}
C {devices/lab_wire.sym} 1595 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} -1440 354 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 865 354 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} -420 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} -1700 430 0 1 {name=l73 lab=net013}
C {devices/lab_wire.sym} -1700 610 2 0 {name=l74 lab=vss}
C {devices/ipin.sym} -1900 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} -1900 380 0 0 {name=p1 lab=VINP}
B 8 -1208 -78 973 78 {fill=0}
T {PMOS Simple Current Mirror (6 outputs)} -1208 -96 0 0 0.3 0.3 {layer=8}
B 10 -1216 182 641 598 {fill=0}
T {NMOS Improved High Swing Cascode Current Mirror [alt: cm.nmos.low_voltage_cascode]} -1216 164 0 0 0.3 0.3 {layer=10}
B 12 -1556 182 981 338 {fill=0}
T {NMOS Simple Current Mirror} -1556 164 0 0 0.3 0.3 {layer=12}
B 21 1075 -78 1703 78 {fill=0}
T {PMOS Simple Current Mirror} 1075 -96 0 0 0.3 0.3 {layer=21}
B 15 1265 182 2363 338 {fill=0}
T {PMOS Differential Pair} 1265 164 0 0 0.3 0.3 {layer=15}
