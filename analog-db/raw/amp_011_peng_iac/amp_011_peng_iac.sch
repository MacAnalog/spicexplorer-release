v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {amp_011_peng_iac} -1955 -200 0 0 0.4 0.4 {}
C {devices/capa_np.sym} -575 260 1 0 {name=C0 value='CAPACITOR_0'}
C {devices/capa_np.sym} 1545 520 1 0 {name=C1 value='CAPACITOR_1'}
C {devices/isource_np.sym} -1915 780 0 0 {name=I0 value='CURRENT_0_BIAS'}
C {devices/res_np.sym} 1225 780 0 0 {name=R0 value='RESISTOR_0'}
C {devices/sg13_lv_pmos_np.sym} -215 0 0 1 {name=M0 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm0_w l=x_dut_xm0_l m=x_dut_xm0_m}
C {devices/sg13_lv_pmos_np.sym} -745 0 0 1 {name=M1 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm1_w l=x_dut_xm1_l m=x_dut_xm1_m}
C {devices/sg13_lv_pmos_np.sym} 1635 0 0 0 {name=M10 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm10_w l=x_dut_xm10_l m=x_dut_xm10_m}
C {devices/sg13_lv_pmos_np.sym} -1530 0 0 1 {name=M11 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm11_w l=x_dut_xm11_l m=x_dut_xm11_m}
C {devices/sg13_lv_nmos_np.sym} -745 520 0 1 {name=M12 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm12_w l=x_dut_xm12_l m=x_dut_xm12_m}
C {devices/sg13_lv_nmos_np.sym} 125 520 0 1 {name=M13 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm13_w l=x_dut_xm13_l m=x_dut_xm13_m}
C {devices/sg13_lv_nmos_np.sym} 955 520 0 0 {name=M14 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm14_w l=x_dut_xm14_l m=x_dut_xm14_m}
C {devices/sg13_lv_nmos_np.sym} -1190 260 0 1 {name=M15 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm15_w l=x_dut_xm15_l m=x_dut_xm15_m}
C {devices/sg13_lv_nmos_np.sym} 510 260 0 0 {name=M16 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm16_w l=x_dut_xm16_l m=x_dut_xm16_m}
C {devices/sg13_lv_nmos_np.sym} -745 780 0 1 {name=M17 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm17_w l=x_dut_xm17_l m=x_dut_xm17_m}
C {devices/sg13_lv_nmos_np.sym} 125 780 0 1 {name=M18 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm18_w l=x_dut_xm18_l m=x_dut_xm18_m}
C {devices/sg13_lv_nmos_np.sym} -1190 520 0 1 {name=M19 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm19_w l=x_dut_xm19_l m=x_dut_xm19_m}
C {devices/sg13_lv_pmos_np.sym} 125 0 0 1 {name=M2 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm2_w l=x_dut_xm2_l m=x_dut_xm2_m}
C {devices/sg13_lv_nmos_np.sym} 510 520 0 0 {name=M20 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm20_w l=x_dut_xm20_l m=x_dut_xm20_m}
C {devices/sg13_lv_nmos_np.sym} -1530 260 0 1 {name=M23 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm23_w l=x_dut_xm23_l m=x_dut_xm23_m}
C {devices/sg13_lv_pmos_np.sym} 955 0 0 0 {name=M3 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm3_w l=x_dut_xm3_l m=x_dut_xm3_m}
C {devices/sg13_lv_pmos_np.sym} 340 0 0 1 {name=M4 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm4_w l=x_dut_xm4_l m=x_dut_xm4_m}
C {devices/sg13_lv_pmos_np.sym} -1190 0 0 1 {name=M5 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm5_w l=x_dut_xm5_l m=x_dut_xm5_m}
C {devices/sg13_lv_pmos_np.sym} -215 260 0 1 {name=M57 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm57_w l=x_dut_xm57_l m=x_dut_xm57_m}
C {devices/sg13_lv_pmos_np.sym} -745 260 0 1 {name=M58 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm58_w l=x_dut_xm58_l m=x_dut_xm58_m}
C {devices/sg13_lv_pmos_np.sym} 510 0 0 0 {name=M6 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm6_w l=x_dut_xm6_l m=x_dut_xm6_m}
C {devices/sg13_lv_pmos_np.sym} 125 260 0 1 {name=M61 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm61_w l=x_dut_xm61_l m=x_dut_xm61_m}
C {devices/sg13_lv_pmos_np.sym} 955 260 0 0 {name=M62 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm62_w l=x_dut_xm62_l m=x_dut_xm62_m}
C {devices/sg13_lv_nmos_np.sym} 1295 260 0 0 {name=M63 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm63_w l=x_dut_xm63_l m=x_dut_xm63_m}
C {devices/sg13_lv_nmos_np.sym} 1295 520 0 0 {name=M64 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm64_w l=x_dut_xm64_l m=x_dut_xm64_m}
C {devices/sg13_lv_pmos_np.sym} 1295 0 0 0 {name=M65 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm65_w l=x_dut_xm65_l m=x_dut_xm65_m}
C {devices/sg13_lv_pmos_np.sym} 2020 260 0 0 {name=M66 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm66_w l=x_dut_xm66_l m=x_dut_xm66_m}
C {devices/sg13_lv_nmos_np.sym} 1635 260 0 0 {name=M67 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm67_w l=x_dut_xm67_l m=x_dut_xm67_m}
C {devices/sg13_lv_nmos_np.sym} 1795 520 0 0 {name=M68 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm68_w l=x_dut_xm68_l m=x_dut_xm68_m}
C {devices/sg13_lv_nmos_np.sym} 2020 520 0 0 {name=M69 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm69_w l=x_dut_xm69_l m=x_dut_xm69_m}
C {devices/sg13_lv_pmos_np.sym} 2020 0 0 0 {name=M7 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm7_w l=x_dut_xm7_l m=x_dut_xm7_m}
C {devices/sg13_lv_nmos_np.sym} 2320 520 0 0 {name=M70 model=sg13_lv_nmos spiceprefix=X w=x_dut_xm70_w l=x_dut_xm70_l m=x_dut_xm70_m}
C {devices/sg13_lv_pmos_np.sym} -970 260 0 1 {name=M8 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm8_w l=x_dut_xm8_l m=x_dut_xm8_m}
C {devices/sg13_lv_pmos_np.sym} 740 260 0 0 {name=M9 model=sg13_lv_pmos spiceprefix=X w=x_dut_xm9_w l=x_dut_xm9_l m=x_dut_xm9_m}
N -1915 690 -1915 750 {}
N -1915 810 -1915 870 {}
N -1610 0 -1610 94 {}
N -1610 260 -1610 354 {}
N -1550 -140 -1550 -30 {}
N -1550 30 -1550 230 {}
N -1550 290 -1550 920 {}
N -1270 0 -1270 94 {}
N -1270 260 -1270 354 {}
N -1270 520 -1270 614 {}
N -1210 -140 -1210 -30 {}
N -1210 30 -1210 70 {}
N -1210 170 -1210 230 {}
N -1210 290 -1210 490 {}
N -1210 550 -1210 920 {}
N -1200 460 -1200 520 {}
N -1170 0 -1170 70 {}
N -1050 260 -1050 354 {}
N -990 170 -990 230 {}
N -990 290 -990 320 {}
N -825 30 -825 230 {}
N -825 260 -825 354 {}
N -825 520 -825 614 {}
N -825 780 -825 874 {}
N -765 -140 -765 -30 {}
N -765 30 -765 90 {}
N -765 290 -765 460 {}
N -765 460 -765 490 {}
N -765 550 -765 750 {}
N -765 810 -765 920 {}
N -725 0 -725 60 {}
N -725 260 -725 320 {}
N -725 400 -725 520 {}
N -695 780 -695 840 {}
N -635 460 -635 780 {}
N -545 260 -545 320 {}
N -295 0 -295 94 {}
N -295 260 -295 354 {}
N -235 -140 -235 -30 {}
N -235 30 -235 90 {}
N -235 170 -235 230 {}
N -235 290 -235 350 {}
N -165 200 -165 260 {}
N 45 0 45 94 {}
N 45 260 45 354 {}
N 45 520 45 614 {}
N 45 780 45 874 {}
N 105 -140 105 -30 {}
N 105 30 105 90 {}
N 105 170 105 230 {}
N 105 290 105 490 {}
N 105 550 105 750 {}
N 105 810 105 920 {}
N 145 200 145 260 {}
N 175 -60 175 0 {}
N 175 200 175 520 {}
N 175 780 175 840 {}
N 260 0 260 94 {}
N 320 -140 320 -30 {}
N 320 30 320 90 {}
N 390 -60 390 0 {}
N 460 200 460 260 {}
N 460 260 460 380 {}
N 470 60 470 230 {}
N 490 -60 490 0 {}
N 520 520 520 780 {}
N 530 -140 530 -30 {}
N 530 30 530 90 {}
N 530 290 530 490 {}
N 530 550 530 920 {}
N 590 0 590 94 {}
N 590 260 590 354 {}
N 590 520 590 614 {}
N 760 170 760 230 {}
N 760 290 760 320 {}
N 820 260 820 354 {}
N 935 -60 935 0 {}
N 935 450 935 520 {}
N 975 -140 975 -30 {}
N 975 30 975 230 {}
N 975 290 975 490 {}
N 975 550 975 920 {}
N 1035 0 1035 94 {}
N 1035 260 1035 354 {}
N 1035 520 1035 614 {}
N 1225 720 1225 750 {}
N 1225 810 1225 920 {}
N 1275 0 1275 70 {}
N 1305 260 1305 320 {}
N 1315 -140 1315 -30 {}
N 1315 30 1315 230 {}
N 1315 290 1315 490 {}
N 1315 550 1315 920 {}
N 1375 0 1375 94 {}
N 1375 260 1375 354 {}
N 1375 520 1375 614 {}
N 1485 520 1485 720 {}
N 1575 520 1575 580 {}
N 1655 -140 1655 -30 {}
N 1655 30 1655 230 {}
N 1655 290 1655 350 {}
N 1715 0 1715 94 {}
N 1715 260 1715 354 {}
N 1815 320 1815 460 {}
N 1815 460 1815 490 {}
N 1815 550 1815 920 {}
N 1875 520 1875 614 {}
N 2040 -140 2040 -30 {}
N 2040 30 2040 230 {}
N 2040 290 2040 350 {}
N 2040 430 2040 490 {}
N 2040 550 2040 920 {}
N 2100 0 2100 94 {}
N 2100 260 2100 354 {}
N 2100 520 2100 614 {}
N 2340 460 2340 490 {}
N 2340 550 2340 920 {}
N 2400 520 2400 614 {}
N -2030 -140 2820 -140 {}
N 175 -60 390 -60 {}
N -1610 0 -1550 0 {}
N -1510 0 -1450 0 {}
N -1270 0 -1210 0 {}
N -725 0 -695 0 {}
N -295 0 -235 0 {}
N -195 0 -135 0 {}
N 45 0 105 0 {}
N 145 0 205 0 {}
N 260 0 320 0 {}
N 360 0 390 0 {}
N 460 0 490 0 {}
N 530 0 590 0 {}
N 905 0 935 0 {}
N 975 0 1035 0 {}
N 1215 0 1275 0 {}
N 1315 0 1375 0 {}
N 1555 0 1615 0 {}
N 1655 0 1715 0 {}
N 1940 0 2000 0 {}
N 2040 0 2100 0 {}
N -825 30 -765 30 {}
N 470 60 530 60 {}
N -1210 70 -1170 70 {}
N 1275 70 1315 70 {}
N -165 200 145 200 {}
N 175 200 460 200 {}
N -825 230 -765 230 {}
N 470 230 530 230 {}
N -1610 260 -1550 260 {}
N -1510 260 -1450 260 {}
N -1270 260 -1210 260 {}
N -1170 260 -1110 260 {}
N -1050 260 -990 260 {}
N -950 260 -920 260 {}
N -825 260 -765 260 {}
N -725 260 -695 260 {}
N -665 260 -605 260 {}
N -545 260 -515 260 {}
N -295 260 -235 260 {}
N -195 260 -135 260 {}
N 45 260 105 260 {}
N 430 260 490 260 {}
N 530 260 590 260 {}
N 630 260 720 260 {}
N 760 260 820 260 {}
N 875 260 935 260 {}
N 975 260 1035 260 {}
N 1245 260 1305 260 {}
N 1315 260 1375 260 {}
N 1555 260 1615 260 {}
N 1655 260 1715 260 {}
N 1940 260 2000 260 {}
N 2040 260 2100 260 {}
N -1210 320 -990 320 {}
N 530 320 760 320 {}
N 975 320 1305 320 {}
N 1655 320 1815 320 {}
N 460 380 975 380 {}
N -725 400 175 400 {}
N 935 450 975 450 {}
N -1200 460 -635 460 {}
N 1755 460 2340 460 {}
N -1270 520 -1210 520 {}
N -1200 520 -1140 520 {}
N -825 520 -765 520 {}
N 45 520 105 520 {}
N 145 520 175 520 {}
N 460 520 520 520 {}
N 530 520 590 520 {}
N 975 520 1035 520 {}
N 1215 520 1275 520 {}
N 1315 520 1375 520 {}
N 1455 520 1515 520 {}
N 1575 520 1605 520 {}
N 1745 520 1775 520 {}
N 1815 520 1875 520 {}
N 1940 520 2000 520 {}
N 2040 520 2100 520 {}
N 2240 520 2300 520 {}
N 2340 520 2400 520 {}
N 1225 720 1485 720 {}
N -825 780 -765 780 {}
N -725 780 -635 780 {}
N 45 780 105 780 {}
N 145 780 520 780 {}
N -695 840 175 840 {}
N -2030 920 2820 920 {}
C {devices/lab_wire.sym} -1210 350 2 0 {name=l0 lab=DM_2}
C {devices/lab_wire.sym} -725 60 2 0 {name=l1 lab=VB1}
C {devices/lab_wire.sym} -235 350 2 0 {name=l2 lab=VB1}
C {devices/lab_wire.sym} -135 0 0 1 {name=l3 lab=VB1}
C {devices/lab_wire.sym} 205 0 0 1 {name=l4 lab=VB1}
C {devices/lab_wire.sym} 935 -60 0 1 {name=l5 lab=VB1}
C {devices/lab_wire.sym} 1940 0 0 0 {name=l6 lab=VB1}
C {devices/lab_wire.sym} -725 320 2 0 {name=l7 lab=VB2}
C {devices/lab_wire.sym} -135 260 0 1 {name=l8 lab=VB2}
C {devices/lab_wire.sym} 875 260 0 0 {name=l9 lab=VB2}
C {devices/lab_wire.sym} 1215 0 0 0 {name=l10 lab=VB2}
C {devices/lab_wire.sym} 1940 260 0 0 {name=l11 lab=VB2}
C {devices/lab_wire.sym} -1110 260 0 1 {name=l12 lab=VB3}
C {devices/lab_wire.sym} 430 260 0 0 {name=l13 lab=VB3}
C {devices/lab_wire.sym} 1555 260 0 0 {name=l14 lab=VB3}
C {devices/lab_wire.sym} -765 350 2 0 {name=l15 lab=VB4}
C {devices/lab_wire.sym} 1215 520 0 0 {name=l16 lab=VB4}
C {devices/lab_wire.sym} 1775 520 0 0 {name=l17 lab=VB4}
C {devices/lab_wire.sym} -1550 90 2 0 {name=l18 lab=VOUT}
C {devices/lab_wire.sym} -665 260 0 0 {name=l19 lab=VOUT}
C {devices/lab_wire.sym} -1170 60 2 0 {name=l20 lab=VOUTN}
C {devices/lab_wire.sym} -1210 170 0 1 {name=l21 lab=VOUTN}
C {devices/lab_wire.sym} 490 -60 0 1 {name=l22 lab=VOUTN}
C {devices/lab_wire.sym} -1450 0 0 1 {name=l23 lab=VOUTP}
C {devices/lab_wire.sym} -545 320 2 0 {name=l24 lab=VOUTP}
C {devices/lab_wire.sym} 530 90 2 0 {name=l25 lab=VOUTP}
C {devices/lab_wire.sym} 1555 0 0 0 {name=l26 lab=VOUTP}
C {devices/lab_wire.sym} 1655 90 2 0 {name=l27 lab=net043}
C {devices/lab_wire.sym} 1940 520 0 0 {name=l28 lab=net043}
C {devices/lab_wire.sym} 2240 520 0 0 {name=l29 lab=net043}
C {devices/lab_wire.sym} 2040 90 2 0 {name=l30 lab=net049}
C {devices/lab_wire.sym} 530 350 2 0 {name=l31 lab=net063}
C {devices/lab_wire.sym} 1655 350 2 0 {name=l32 lab=net1}
C {devices/lab_wire.sym} -1450 260 0 1 {name=l33 lab=net10}
C {devices/lab_wire.sym} 1575 580 2 0 {name=l34 lab=net10}
C {devices/lab_wire.sym} 2040 350 2 0 {name=l35 lab=net10}
C {devices/lab_wire.sym} 2040 430 0 1 {name=l36 lab=net10}
C {devices/lab_wire.sym} -235 90 2 0 {name=l37 lab=net2}
C {devices/lab_wire.sym} -235 170 0 1 {name=l38 lab=net2}
C {devices/lab_wire.sym} -765 90 2 0 {name=l39 lab=net3}
C {devices/lab_wire.sym} -990 170 0 1 {name=l40 lab=net31}
C {devices/lab_wire.sym} 320 90 2 0 {name=l41 lab=net31}
C {devices/lab_wire.sym} 760 170 0 1 {name=l42 lab=net31}
C {devices/lab_wire.sym} 1455 520 0 0 {name=l43 lab=net4}
C {devices/lab_wire.sym} -765 610 2 0 {name=l44 lab=net54}
C {devices/lab_wire.sym} 105 610 2 0 {name=l45 lab=net56}
C {devices/lab_wire.sym} 105 90 2 0 {name=l46 lab=net6}
C {devices/lab_wire.sym} 105 170 0 1 {name=l47 lab=net6}
C {devices/lab_wire.sym} 105 350 2 0 {name=l48 lab=net7}
C {devices/lab_wire.sym} 975 90 2 0 {name=l49 lab=net8}
C {devices/lab_wire.sym} 1315 350 2 0 {name=l50 lab=net9}
C {devices/lab_wire.sym} -1050 354 2 0 {name=l51 lab=net31}
C {devices/lab_wire.sym} 820 354 2 0 {name=l52 lab=net31}
C {devices/lab_wire.sym} -295 94 2 0 {name=l53 lab=vdd}
C {devices/lab_wire.sym} -765 0 0 0 {name=l54 lab=vdd}
C {devices/lab_wire.sym} 1715 94 2 0 {name=l55 lab=vdd}
C {devices/lab_wire.sym} -1610 94 2 0 {name=l56 lab=vdd}
C {devices/lab_wire.sym} 45 94 2 0 {name=l57 lab=vdd}
C {devices/lab_wire.sym} 1035 94 2 0 {name=l58 lab=vdd}
C {devices/lab_wire.sym} 260 94 2 0 {name=l59 lab=vdd}
C {devices/lab_wire.sym} -1270 94 2 0 {name=l60 lab=vdd}
C {devices/lab_wire.sym} -295 354 2 0 {name=l61 lab=vdd}
C {devices/lab_wire.sym} -825 354 2 0 {name=l62 lab=vdd}
C {devices/lab_wire.sym} 590 94 2 0 {name=l63 lab=vdd}
C {devices/lab_wire.sym} 45 354 2 0 {name=l64 lab=vdd}
C {devices/lab_wire.sym} 1035 354 2 0 {name=l65 lab=vdd}
C {devices/lab_wire.sym} 1375 94 2 0 {name=l66 lab=vdd}
C {devices/lab_wire.sym} 2100 354 2 0 {name=l67 lab=vdd}
C {devices/lab_wire.sym} 2100 94 2 0 {name=l68 lab=vdd}
C {devices/lab_wire.sym} -825 614 2 0 {name=l69 lab=vss}
C {devices/lab_wire.sym} 45 614 2 0 {name=l70 lab=vss}
C {devices/lab_wire.sym} 1035 614 2 0 {name=l71 lab=vss}
C {devices/lab_wire.sym} -1270 354 2 0 {name=l72 lab=vss}
C {devices/lab_wire.sym} 590 354 2 0 {name=l73 lab=vss}
C {devices/lab_wire.sym} -825 874 2 0 {name=l74 lab=vss}
C {devices/lab_wire.sym} 45 874 2 0 {name=l75 lab=vss}
C {devices/lab_wire.sym} -1270 614 2 0 {name=l76 lab=vss}
C {devices/lab_wire.sym} 590 614 2 0 {name=l77 lab=vss}
C {devices/lab_wire.sym} -1610 354 2 0 {name=l78 lab=vss}
C {devices/lab_wire.sym} 1375 354 2 0 {name=l79 lab=vss}
C {devices/lab_wire.sym} 1375 614 2 0 {name=l80 lab=vss}
C {devices/lab_wire.sym} 1715 354 2 0 {name=l81 lab=vss}
C {devices/lab_wire.sym} 1875 614 2 0 {name=l82 lab=vss}
C {devices/lab_wire.sym} 2100 614 2 0 {name=l83 lab=vss}
C {devices/lab_wire.sym} 2400 614 2 0 {name=l84 lab=vss}
C {devices/lab_wire.sym} -1915 690 0 1 {name=l85 lab=VB1}
C {devices/lab_wire.sym} -1915 870 2 0 {name=l86 lab=vss}
C {devices/ipin.sym} -920 260 0 0 {name=p0 lab=VINN}
C {devices/ipin.sym} 630 260 0 0 {name=p1 lab=VINP}
C {devices/iopin.sym} -2030 -140 0 0 {name=p2 lab=vdd}
C {devices/iopin.sym} -2030 920 0 0 {name=p3 lab=vss}
